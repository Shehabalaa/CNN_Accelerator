$ Spice netlist generated by v2lvs
$ v2019.1_18.11    Thu Jan 10 13:52:35 PST 2019
*.BUSDELIMITER [

.SUBCKT FcMain cnnDone ioDone clk reset defaultAddressNeorons[12]
+ defaultAddressNeorons[11] defaultAddressNeorons[10] defaultAddressNeorons[9]
+ defaultAddressNeorons[8] defaultAddressNeorons[7] defaultAddressNeorons[6]
+ defaultAddressNeorons[5] defaultAddressNeorons[4] defaultAddressNeorons[3]
+ defaultAddressNeorons[2] defaultAddressNeorons[1] defaultAddressNeorons[0]
+ dmaAddRamNeorons[12] dmaAddRamNeorons[11] dmaAddRamNeorons[10]
+ dmaAddRamNeorons[9] dmaAddRamNeorons[8] dmaAddRamNeorons[7]
+ dmaAddRamNeorons[6] dmaAddRamNeorons[5] dmaAddRamNeorons[4]
+ dmaAddRamNeorons[3] dmaAddRamNeorons[2] dmaAddRamNeorons[1]
+ dmaAddRamNeorons[0] readRamNeorons finishRamNeorons dataOutRamNeorons[79]
+ dataOutRamNeorons[78] dataOutRamNeorons[77] dataOutRamNeorons[76]
+ dataOutRamNeorons[75] dataOutRamNeorons[74] dataOutRamNeorons[73]
+ dataOutRamNeorons[72] dataOutRamNeorons[71] dataOutRamNeorons[70]
+ dataOutRamNeorons[69] dataOutRamNeorons[68] dataOutRamNeorons[67]
+ dataOutRamNeorons[66] dataOutRamNeorons[65] dataOutRamNeorons[64]
+ dataOutRamNeorons[63] dataOutRamNeorons[62] dataOutRamNeorons[61]
+ dataOutRamNeorons[60] dataOutRamNeorons[59] dataOutRamNeorons[58]
+ dataOutRamNeorons[57] dataOutRamNeorons[56] dataOutRamNeorons[55]
+ dataOutRamNeorons[54] dataOutRamNeorons[53] dataOutRamNeorons[52]
+ dataOutRamNeorons[51] dataOutRamNeorons[50] dataOutRamNeorons[49]
+ dataOutRamNeorons[48] dataOutRamNeorons[47] dataOutRamNeorons[46]
+ dataOutRamNeorons[45] dataOutRamNeorons[44] dataOutRamNeorons[43]
+ dataOutRamNeorons[42] dataOutRamNeorons[41] dataOutRamNeorons[40]
+ dataOutRamNeorons[39] dataOutRamNeorons[38] dataOutRamNeorons[37]
+ dataOutRamNeorons[36] dataOutRamNeorons[35] dataOutRamNeorons[34]
+ dataOutRamNeorons[33] dataOutRamNeorons[32] dataOutRamNeorons[31]
+ dataOutRamNeorons[30] dataOutRamNeorons[29] dataOutRamNeorons[28]
+ dataOutRamNeorons[27] dataOutRamNeorons[26] dataOutRamNeorons[25]
+ dataOutRamNeorons[24] dataOutRamNeorons[23] dataOutRamNeorons[22]
+ dataOutRamNeorons[21] dataOutRamNeorons[20] dataOutRamNeorons[19]
+ dataOutRamNeorons[18] dataOutRamNeorons[17] dataOutRamNeorons[16]
+ dataOutRamNeorons[15] dataOutRamNeorons[14] dataOutRamNeorons[13]
+ dataOutRamNeorons[12] dataOutRamNeorons[11] dataOutRamNeorons[10]
+ dataOutRamNeorons[9] dataOutRamNeorons[8] dataOutRamNeorons[7]
+ dataOutRamNeorons[6] dataOutRamNeorons[5] dataOutRamNeorons[4]
+ dataOutRamNeorons[3] dataOutRamNeorons[2] dataOutRamNeorons[1]
+ dataOutRamNeorons[0] dmaAddRamWeights[15] dmaAddRamWeights[14]
+ dmaAddRamWeights[13] dmaAddRamWeights[12] dmaAddRamWeights[11]
+ dmaAddRamWeights[10] dmaAddRamWeights[9] dmaAddRamWeights[8]
+ dmaAddRamWeights[7] dmaAddRamWeights[6] dmaAddRamWeights[5]
+ dmaAddRamWeights[4] dmaAddRamWeights[3] dmaAddRamWeights[2]
+ dmaAddRamWeights[1] dmaAddRamWeights[0] readRamWeights finishRamWeights
+ dataOutRamWeights[79] dataOutRamWeights[78] dataOutRamWeights[77]
+ dataOutRamWeights[76] dataOutRamWeights[75] dataOutRamWeights[74]
+ dataOutRamWeights[73] dataOutRamWeights[72] dataOutRamWeights[71]
+ dataOutRamWeights[70] dataOutRamWeights[69] dataOutRamWeights[68]
+ dataOutRamWeights[67] dataOutRamWeights[66] dataOutRamWeights[65]
+ dataOutRamWeights[64] dataOutRamWeights[63] dataOutRamWeights[62]
+ dataOutRamWeights[61] dataOutRamWeights[60] dataOutRamWeights[59]
+ dataOutRamWeights[58] dataOutRamWeights[57] dataOutRamWeights[56]
+ dataOutRamWeights[55] dataOutRamWeights[54] dataOutRamWeights[53]
+ dataOutRamWeights[52] dataOutRamWeights[51] dataOutRamWeights[50]
+ dataOutRamWeights[49] dataOutRamWeights[48] dataOutRamWeights[47]
+ dataOutRamWeights[46] dataOutRamWeights[45] dataOutRamWeights[44]
+ dataOutRamWeights[43] dataOutRamWeights[42] dataOutRamWeights[41]
+ dataOutRamWeights[40] dataOutRamWeights[39] dataOutRamWeights[38]
+ dataOutRamWeights[37] dataOutRamWeights[36] dataOutRamWeights[35]
+ dataOutRamWeights[34] dataOutRamWeights[33] dataOutRamWeights[32]
+ dataOutRamWeights[31] dataOutRamWeights[30] dataOutRamWeights[29]
+ dataOutRamWeights[28] dataOutRamWeights[27] dataOutRamWeights[26]
+ dataOutRamWeights[25] dataOutRamWeights[24] dataOutRamWeights[23]
+ dataOutRamWeights[22] dataOutRamWeights[21] dataOutRamWeights[20]
+ dataOutRamWeights[19] dataOutRamWeights[18] dataOutRamWeights[17]
+ dataOutRamWeights[16] dataOutRamWeights[15] dataOutRamWeights[14]
+ dataOutRamWeights[13] dataOutRamWeights[12] dataOutRamWeights[11]
+ dataOutRamWeights[10] dataOutRamWeights[9] dataOutRamWeights[8]
+ dataOutRamWeights[7] dataOutRamWeights[6] dataOutRamWeights[5]
+ dataOutRamWeights[4] dataOutRamWeights[3] dataOutRamWeights[2]
+ dataOutRamWeights[1] dataOutRamWeights[0] fcDone MAXPrediction[3]
+ MAXPrediction[2] MAXPrediction[1] MAXPrediction[0]
XCNNDONEHOLDER RisingHolderFullCycle $PINS transition=beginSignal clk=clk
+ rst=reset f=cnnDoneOneCycle
XNEORONSLASTSTAGES CounterUpDown_16 $PINS load[15]=dataOutRamWeights[15]
+ load[14]=dataOutRamWeights[14] load[13]=dataOutRamWeights[13]
+ load[12]=dataOutRamWeights[12] load[11]=dataOutRamWeights[11]
+ load[10]=dataOutRamWeights[10] load[9]=dataOutRamWeights[9]
+ load[8]=dataOutRamWeights[8] load[7]=dataOutRamWeights[7]
+ load[6]=dataOutRamWeights[6] load[5]=dataOutRamWeights[5]
+ load[4]=dataOutRamWeights[4] load[3]=dataOutRamWeights[3]
+ load[2]=dataOutRamWeights[2] load[1]=dataOutRamWeights[1]
+ load[0]=dataOutRamWeights[0] resetValue[15]=oneNeoron_15
+ resetValue[14]=oneNeoron_15 resetValue[13]=oneNeoron_15
+ resetValue[12]=oneNeoron_15 resetValue[11]=oneNeoron_15
+ resetValue[10]=oneNeoron_15 resetValue[9]=oneNeoron_15
+ resetValue[8]=oneNeoron_15 resetValue[7]=oneNeoron_15
+ resetValue[6]=oneNeoron_15 resetValue[5]=oneNeoron_15
+ resetValue[4]=oneNeoron_15 resetValue[3]=oneNeoron_15
+ resetValue[2]=oneNeoron_15 resetValue[1]=oneNeoron_15
+ resetValue[0]=oneNeoron_15 clk=clk en=decrement rst=reset isLoad=nx1326
+ upOrDown=oneNeoron_8 count[15]=numberOFNeorons_15 count[14]=numberOFNeorons_14
+ count[13]=numberOFNeorons_13 count[12]=numberOFNeorons_12
+ count[11]=numberOFNeorons_11 count[10]=numberOFNeorons_10
+ count[9]=numberOFNeorons_9 count[8]=numberOFNeorons_8
+ count[7]=numberOFNeorons_7 count[6]=numberOFNeorons_6
+ count[5]=numberOFNeorons_5 count[4]=numberOFNeorons_4
+ count[3]=numberOFNeorons_3 count[2]=numberOFNeorons_2
+ count[1]=numberOFNeorons_1 count[0]=numberOFNeorons_0
XNEORONREGMux Mux2_16 $PINS A[15]=dataOutRamNeorons[15]
+ A[14]=dataOutRamNeorons[14] A[13]=dataOutRamNeorons[13]
+ A[12]=dataOutRamNeorons[12] A[11]=dataOutRamNeorons[11]
+ A[10]=dataOutRamNeorons[10] A[9]=dataOutRamNeorons[9] A[8]=dataOutRamNeorons[8]
+ A[7]=dataOutRamNeorons[7] A[6]=dataOutRamNeorons[6] A[5]=dataOutRamNeorons[5]
+ A[4]=dataOutRamNeorons[4] A[3]=dataOutRamNeorons[3] A[2]=dataOutRamNeorons[2]
+ A[1]=dataOutRamNeorons[1] A[0]=dataOutRamNeorons[0] B[15]=oneNeoron_15
+ B[14]=oneNeoron_15 B[13]=oneNeoron_15 B[12]=oneNeoron_15 B[11]=oneNeoron_15
+ B[10]=oneNeoron_15 B[9]=oneNeoron_15 B[8]=oneNeoron_8 B[7]=oneNeoron_15
+ B[6]=oneNeoron_15 B[5]=oneNeoron_15 B[4]=oneNeoron_15 B[3]=oneNeoron_15
+ B[2]=oneNeoron_15 B[1]=oneNeoron_15 B[0]=oneNeoron_15 S=neoronValueSelection
+ C[15]=neoronMuxOutput_15 C[14]=neoronMuxOutput_14 C[13]=neoronMuxOutput_13
+ C[12]=neoronMuxOutput_12 C[11]=neoronMuxOutput_11 C[10]=neoronMuxOutput_10
+ C[9]=neoronMuxOutput_9 C[8]=neoronMuxOutput_8 C[7]=neoronMuxOutput_7
+ C[6]=neoronMuxOutput_6 C[5]=neoronMuxOutput_5 C[4]=neoronMuxOutput_4
+ C[3]=neoronMuxOutput_3 C[2]=neoronMuxOutput_2 C[1]=neoronMuxOutput_1
+ C[0]=neoronMuxOutput_0
XMAXIMIZATIONMAP ngetMax_16_10 $PINS inputArray_9__15=labelReg_9__15
+ inputArray_9__14=labelReg_9__14 inputArray_9__13=labelReg_9__13
+ inputArray_9__12=labelReg_9__12 inputArray_9__11=labelReg_9__11
+ inputArray_9__10=labelReg_9__10 inputArray_9__9=labelReg_9__9
+ inputArray_9__8=labelReg_9__8 inputArray_9__7=labelReg_9__7
+ inputArray_9__6=labelReg_9__6 inputArray_9__5=labelReg_9__5
+ inputArray_9__4=labelReg_9__4 inputArray_9__3=labelReg_9__3
+ inputArray_9__2=labelReg_9__2 inputArray_9__1=labelReg_9__1
+ inputArray_9__0=labelReg_9__0 inputArray_8__15=labelReg_8__15
+ inputArray_8__14=labelReg_8__14 inputArray_8__13=labelReg_8__13
+ inputArray_8__12=labelReg_8__12 inputArray_8__11=labelReg_8__11
+ inputArray_8__10=labelReg_8__10 inputArray_8__9=labelReg_8__9
+ inputArray_8__8=labelReg_8__8 inputArray_8__7=labelReg_8__7
+ inputArray_8__6=labelReg_8__6 inputArray_8__5=labelReg_8__5
+ inputArray_8__4=labelReg_8__4 inputArray_8__3=labelReg_8__3
+ inputArray_8__2=labelReg_8__2 inputArray_8__1=labelReg_8__1
+ inputArray_8__0=labelReg_8__0 inputArray_7__15=labelReg_7__15
+ inputArray_7__14=labelReg_7__14 inputArray_7__13=labelReg_7__13
+ inputArray_7__12=labelReg_7__12 inputArray_7__11=labelReg_7__11
+ inputArray_7__10=labelReg_7__10 inputArray_7__9=labelReg_7__9
+ inputArray_7__8=labelReg_7__8 inputArray_7__7=labelReg_7__7
+ inputArray_7__6=labelReg_7__6 inputArray_7__5=labelReg_7__5
+ inputArray_7__4=labelReg_7__4 inputArray_7__3=labelReg_7__3
+ inputArray_7__2=labelReg_7__2 inputArray_7__1=labelReg_7__1
+ inputArray_7__0=labelReg_7__0 inputArray_6__15=labelReg_6__15
+ inputArray_6__14=labelReg_6__14 inputArray_6__13=labelReg_6__13
+ inputArray_6__12=labelReg_6__12 inputArray_6__11=labelReg_6__11
+ inputArray_6__10=labelReg_6__10 inputArray_6__9=labelReg_6__9
+ inputArray_6__8=labelReg_6__8 inputArray_6__7=labelReg_6__7
+ inputArray_6__6=labelReg_6__6 inputArray_6__5=labelReg_6__5
+ inputArray_6__4=labelReg_6__4 inputArray_6__3=labelReg_6__3
+ inputArray_6__2=labelReg_6__2 inputArray_6__1=labelReg_6__1
+ inputArray_6__0=labelReg_6__0 inputArray_5__15=labelReg_5__15
+ inputArray_5__14=labelReg_5__14 inputArray_5__13=labelReg_5__13
+ inputArray_5__12=labelReg_5__12 inputArray_5__11=labelReg_5__11
+ inputArray_5__10=labelReg_5__10 inputArray_5__9=labelReg_5__9
+ inputArray_5__8=labelReg_5__8 inputArray_5__7=labelReg_5__7
+ inputArray_5__6=labelReg_5__6 inputArray_5__5=labelReg_5__5
+ inputArray_5__4=labelReg_5__4 inputArray_5__3=labelReg_5__3
+ inputArray_5__2=labelReg_5__2 inputArray_5__1=labelReg_5__1
+ inputArray_5__0=labelReg_5__0 inputArray_4__15=labelReg_4__15
+ inputArray_4__14=labelReg_4__14 inputArray_4__13=labelReg_4__13
+ inputArray_4__12=labelReg_4__12 inputArray_4__11=labelReg_4__11
+ inputArray_4__10=labelReg_4__10 inputArray_4__9=labelReg_4__9
+ inputArray_4__8=labelReg_4__8 inputArray_4__7=labelReg_4__7
+ inputArray_4__6=labelReg_4__6 inputArray_4__5=labelReg_4__5
+ inputArray_4__4=labelReg_4__4 inputArray_4__3=labelReg_4__3
+ inputArray_4__2=labelReg_4__2 inputArray_4__1=labelReg_4__1
+ inputArray_4__0=labelReg_4__0 inputArray_3__15=labelReg_3__15
+ inputArray_3__14=labelReg_3__14 inputArray_3__13=labelReg_3__13
+ inputArray_3__12=labelReg_3__12 inputArray_3__11=labelReg_3__11
+ inputArray_3__10=labelReg_3__10 inputArray_3__9=labelReg_3__9
+ inputArray_3__8=labelReg_3__8 inputArray_3__7=labelReg_3__7
+ inputArray_3__6=labelReg_3__6 inputArray_3__5=labelReg_3__5
+ inputArray_3__4=labelReg_3__4 inputArray_3__3=labelReg_3__3
+ inputArray_3__2=labelReg_3__2 inputArray_3__1=labelReg_3__1
+ inputArray_3__0=labelReg_3__0 inputArray_2__15=labelReg_2__15
+ inputArray_2__14=labelReg_2__14 inputArray_2__13=labelReg_2__13
+ inputArray_2__12=labelReg_2__12 inputArray_2__11=labelReg_2__11
+ inputArray_2__10=labelReg_2__10 inputArray_2__9=labelReg_2__9
+ inputArray_2__8=labelReg_2__8 inputArray_2__7=labelReg_2__7
+ inputArray_2__6=labelReg_2__6 inputArray_2__5=labelReg_2__5
+ inputArray_2__4=labelReg_2__4 inputArray_2__3=labelReg_2__3
+ inputArray_2__2=labelReg_2__2 inputArray_2__1=labelReg_2__1
+ inputArray_2__0=labelReg_2__0 inputArray_1__15=labelReg_1__15
+ inputArray_1__14=labelReg_1__14 inputArray_1__13=labelReg_1__13
+ inputArray_1__12=labelReg_1__12 inputArray_1__11=labelReg_1__11
+ inputArray_1__10=labelReg_1__10 inputArray_1__9=labelReg_1__9
+ inputArray_1__8=labelReg_1__8 inputArray_1__7=labelReg_1__7
+ inputArray_1__6=labelReg_1__6 inputArray_1__5=labelReg_1__5
+ inputArray_1__4=labelReg_1__4 inputArray_1__3=labelReg_1__3
+ inputArray_1__2=labelReg_1__2 inputArray_1__1=labelReg_1__1
+ inputArray_1__0=labelReg_1__0 inputArray_0__15=labelReg_0__15
+ inputArray_0__14=labelReg_0__14 inputArray_0__13=labelReg_0__13
+ inputArray_0__12=labelReg_0__12 inputArray_0__11=labelReg_0__11
+ inputArray_0__10=labelReg_0__10 inputArray_0__9=labelReg_0__9
+ inputArray_0__8=labelReg_0__8 inputArray_0__7=labelReg_0__7
+ inputArray_0__6=labelReg_0__6 inputArray_0__5=labelReg_0__5
+ inputArray_0__4=labelReg_0__4 inputArray_0__3=labelReg_0__3
+ inputArray_0__2=labelReg_0__2 inputArray_0__1=labelReg_0__1
+ inputArray_0__0=labelReg_0__0 en=state_6 clk=clk rst=state_10
+ outLabel[3]=maxNumber_3 outLabel[2]=maxNumber_2 outLabel[1]=maxNumber_1
+ outLabel[0]=maxNumber_0 done=doneMax
XALUMAP Alus8x16_10 $PINS q_9__7=dataOutRamWeights[79]
+ q_9__6=dataOutRamWeights[78] q_9__5=dataOutRamWeights[77]
+ q_9__4=dataOutRamWeights[76] q_9__3=dataOutRamWeights[75]
+ q_9__2=dataOutRamWeights[74] q_9__1=dataOutRamWeights[73]
+ q_9__0=dataOutRamWeights[72] q_8__7=dataOutRamWeights[71]
+ q_8__6=dataOutRamWeights[70] q_8__5=dataOutRamWeights[69]
+ q_8__4=dataOutRamWeights[68] q_8__3=dataOutRamWeights[67]
+ q_8__2=dataOutRamWeights[66] q_8__1=dataOutRamWeights[65]
+ q_8__0=dataOutRamWeights[64] q_7__7=dataOutRamWeights[63]
+ q_7__6=dataOutRamWeights[62] q_7__5=dataOutRamWeights[61]
+ q_7__4=dataOutRamWeights[60] q_7__3=dataOutRamWeights[59]
+ q_7__2=dataOutRamWeights[58] q_7__1=dataOutRamWeights[57]
+ q_7__0=dataOutRamWeights[56] q_6__7=dataOutRamWeights[55]
+ q_6__6=dataOutRamWeights[54] q_6__5=dataOutRamWeights[53]
+ q_6__4=dataOutRamWeights[52] q_6__3=dataOutRamWeights[51]
+ q_6__2=dataOutRamWeights[50] q_6__1=dataOutRamWeights[49]
+ q_6__0=dataOutRamWeights[48] q_5__7=dataOutRamWeights[47]
+ q_5__6=dataOutRamWeights[46] q_5__5=dataOutRamWeights[45]
+ q_5__4=dataOutRamWeights[44] q_5__3=dataOutRamWeights[43]
+ q_5__2=dataOutRamWeights[42] q_5__1=dataOutRamWeights[41]
+ q_5__0=dataOutRamWeights[40] q_4__7=dataOutRamWeights[39]
+ q_4__6=dataOutRamWeights[38] q_4__5=dataOutRamWeights[37]
+ q_4__4=dataOutRamWeights[36] q_4__3=dataOutRamWeights[35]
+ q_4__2=dataOutRamWeights[34] q_4__1=dataOutRamWeights[33]
+ q_4__0=dataOutRamWeights[32] q_3__7=dataOutRamWeights[31]
+ q_3__6=dataOutRamWeights[30] q_3__5=dataOutRamWeights[29]
+ q_3__4=dataOutRamWeights[28] q_3__3=dataOutRamWeights[27]
+ q_3__2=dataOutRamWeights[26] q_3__1=dataOutRamWeights[25]
+ q_3__0=dataOutRamWeights[24] q_2__7=dataOutRamWeights[23]
+ q_2__6=dataOutRamWeights[22] q_2__5=dataOutRamWeights[21]
+ q_2__4=dataOutRamWeights[20] q_2__3=dataOutRamWeights[19]
+ q_2__2=dataOutRamWeights[18] q_2__1=dataOutRamWeights[17]
+ q_2__0=dataOutRamWeights[16] q_1__7=dataOutRamWeights[15]
+ q_1__6=dataOutRamWeights[14] q_1__5=dataOutRamWeights[13]
+ q_1__4=dataOutRamWeights[12] q_1__3=dataOutRamWeights[11]
+ q_1__2=dataOutRamWeights[10] q_1__1=dataOutRamWeights[9]
+ q_1__0=dataOutRamWeights[8] q_0__7=dataOutRamWeights[7]
+ q_0__6=dataOutRamWeights[6] q_0__5=dataOutRamWeights[5]
+ q_0__4=dataOutRamWeights[4] q_0__3=dataOutRamWeights[3]
+ q_0__2=dataOutRamWeights[2] q_0__1=dataOutRamWeights[1]
+ q_0__0=dataOutRamWeights[0] m_9__15=nx1160 m_9__14=nx1170 m_9__13=nx1180
+ m_9__12=nx1190 m_9__11=nx1200 m_9__10=nx1210 m_9__9=nx1220 m_9__8=nx1230
+ m_9__7=nx1240 m_9__6=nx1250 m_9__5=nx1260 m_9__4=nx1270 m_9__3=nx1280
+ m_9__2=nx1290 m_9__1=nx1300 m_9__0=nx1310 m_8__15=nx1160 m_8__14=nx1170
+ m_8__13=nx1180 m_8__12=nx1190 m_8__11=nx1200 m_8__10=nx1210 m_8__9=nx1220
+ m_8__8=nx1230 m_8__7=nx1240 m_8__6=nx1250 m_8__5=nx1260 m_8__4=nx1270
+ m_8__3=nx1280 m_8__2=nx1290 m_8__1=nx1300 m_8__0=nx1310 m_7__15=nx1160
+ m_7__14=nx1170 m_7__13=nx1180 m_7__12=nx1190 m_7__11=nx1200 m_7__10=nx1210
+ m_7__9=nx1220 m_7__8=nx1230 m_7__7=nx1240 m_7__6=nx1250 m_7__5=nx1260
+ m_7__4=nx1270 m_7__3=nx1280 m_7__2=nx1290 m_7__1=nx1300 m_7__0=nx1310
+ m_6__15=nx1162 m_6__14=nx1172 m_6__13=nx1182 m_6__12=nx1192 m_6__11=nx1202
+ m_6__10=nx1212 m_6__9=nx1222 m_6__8=nx1232 m_6__7=nx1242 m_6__6=nx1252
+ m_6__5=nx1262 m_6__4=nx1272 m_6__3=nx1282 m_6__2=nx1292 m_6__1=nx1302
+ m_6__0=nx1312 m_5__15=nx1162 m_5__14=nx1172 m_5__13=nx1182 m_5__12=nx1192
+ m_5__11=nx1202 m_5__10=nx1212 m_5__9=nx1222 m_5__8=nx1232 m_5__7=nx1242
+ m_5__6=nx1252 m_5__5=nx1262 m_5__4=nx1272 m_5__3=nx1282 m_5__2=nx1292
+ m_5__1=nx1302 m_5__0=nx1312 m_4__15=nx1162 m_4__14=nx1172 m_4__13=nx1182
+ m_4__12=nx1192 m_4__11=nx1202 m_4__10=nx1212 m_4__9=nx1222 m_4__8=nx1232
+ m_4__7=nx1242 m_4__6=nx1252 m_4__5=nx1262 m_4__4=nx1272 m_4__3=nx1282
+ m_4__2=nx1292 m_4__1=nx1302 m_4__0=nx1312 m_3__15=nx1164 m_3__14=nx1174
+ m_3__13=nx1184 m_3__12=nx1194 m_3__11=nx1204 m_3__10=nx1214 m_3__9=nx1224
+ m_3__8=nx1234 m_3__7=nx1244 m_3__6=nx1254 m_3__5=nx1264 m_3__4=nx1274
+ m_3__3=nx1284 m_3__2=nx1294 m_3__1=nx1304 m_3__0=nx1314 m_2__15=nx1164
+ m_2__14=nx1174 m_2__13=nx1184 m_2__12=nx1194 m_2__11=nx1204 m_2__10=nx1214
+ m_2__9=nx1224 m_2__8=nx1234 m_2__7=nx1244 m_2__6=nx1254 m_2__5=nx1264
+ m_2__4=nx1274 m_2__3=nx1284 m_2__2=nx1294 m_2__1=nx1304 m_2__0=nx1314
+ m_1__15=nx1164 m_1__14=nx1174 m_1__13=nx1184 m_1__12=nx1194 m_1__11=nx1204
+ m_1__10=nx1214 m_1__9=nx1224 m_1__8=nx1234 m_1__7=nx1244 m_1__6=nx1254
+ m_1__5=nx1264 m_1__4=nx1274 m_1__3=nx1284 m_1__2=nx1294 m_1__1=nx1304
+ m_1__0=nx1314 m_0__15=nx1166 m_0__14=nx1176 m_0__13=nx1186 m_0__12=nx1196
+ m_0__11=nx1206 m_0__10=nx1216 m_0__9=nx1226 m_0__8=nx1236 m_0__7=nx1246
+ m_0__6=nx1256 m_0__5=nx1266 m_0__4=nx1276 m_0__3=nx1286 m_0__2=nx1296
+ m_0__1=nx1306 m_0__0=nx1316 f_9__15=labelReg_9__15 f_9__14=labelReg_9__14
+ f_9__13=labelReg_9__13 f_9__12=labelReg_9__12 f_9__11=labelReg_9__11
+ f_9__10=labelReg_9__10 f_9__9=labelReg_9__9 f_9__8=labelReg_9__8
+ f_9__7=labelReg_9__7 f_9__6=labelReg_9__6 f_9__5=labelReg_9__5
+ f_9__4=labelReg_9__4 f_9__3=labelReg_9__3 f_9__2=labelReg_9__2
+ f_9__1=labelReg_9__1 f_9__0=labelReg_9__0 f_8__15=labelReg_8__15
+ f_8__14=labelReg_8__14 f_8__13=labelReg_8__13 f_8__12=labelReg_8__12
+ f_8__11=labelReg_8__11 f_8__10=labelReg_8__10 f_8__9=labelReg_8__9
+ f_8__8=labelReg_8__8 f_8__7=labelReg_8__7 f_8__6=labelReg_8__6
+ f_8__5=labelReg_8__5 f_8__4=labelReg_8__4 f_8__3=labelReg_8__3
+ f_8__2=labelReg_8__2 f_8__1=labelReg_8__1 f_8__0=labelReg_8__0
+ f_7__15=labelReg_7__15 f_7__14=labelReg_7__14 f_7__13=labelReg_7__13
+ f_7__12=labelReg_7__12 f_7__11=labelReg_7__11 f_7__10=labelReg_7__10
+ f_7__9=labelReg_7__9 f_7__8=labelReg_7__8 f_7__7=labelReg_7__7
+ f_7__6=labelReg_7__6 f_7__5=labelReg_7__5 f_7__4=labelReg_7__4
+ f_7__3=labelReg_7__3 f_7__2=labelReg_7__2 f_7__1=labelReg_7__1
+ f_7__0=labelReg_7__0 f_6__15=labelReg_6__15 f_6__14=labelReg_6__14
+ f_6__13=labelReg_6__13 f_6__12=labelReg_6__12 f_6__11=labelReg_6__11
+ f_6__10=labelReg_6__10 f_6__9=labelReg_6__9 f_6__8=labelReg_6__8
+ f_6__7=labelReg_6__7 f_6__6=labelReg_6__6 f_6__5=labelReg_6__5
+ f_6__4=labelReg_6__4 f_6__3=labelReg_6__3 f_6__2=labelReg_6__2
+ f_6__1=labelReg_6__1 f_6__0=labelReg_6__0 f_5__15=labelReg_5__15
+ f_5__14=labelReg_5__14 f_5__13=labelReg_5__13 f_5__12=labelReg_5__12
+ f_5__11=labelReg_5__11 f_5__10=labelReg_5__10 f_5__9=labelReg_5__9
+ f_5__8=labelReg_5__8 f_5__7=labelReg_5__7 f_5__6=labelReg_5__6
+ f_5__5=labelReg_5__5 f_5__4=labelReg_5__4 f_5__3=labelReg_5__3
+ f_5__2=labelReg_5__2 f_5__1=labelReg_5__1 f_5__0=labelReg_5__0
+ f_4__15=labelReg_4__15 f_4__14=labelReg_4__14 f_4__13=labelReg_4__13
+ f_4__12=labelReg_4__12 f_4__11=labelReg_4__11 f_4__10=labelReg_4__10
+ f_4__9=labelReg_4__9 f_4__8=labelReg_4__8 f_4__7=labelReg_4__7
+ f_4__6=labelReg_4__6 f_4__5=labelReg_4__5 f_4__4=labelReg_4__4
+ f_4__3=labelReg_4__3 f_4__2=labelReg_4__2 f_4__1=labelReg_4__1
+ f_4__0=labelReg_4__0 f_3__15=labelReg_3__15 f_3__14=labelReg_3__14
+ f_3__13=labelReg_3__13 f_3__12=labelReg_3__12 f_3__11=labelReg_3__11
+ f_3__10=labelReg_3__10 f_3__9=labelReg_3__9 f_3__8=labelReg_3__8
+ f_3__7=labelReg_3__7 f_3__6=labelReg_3__6 f_3__5=labelReg_3__5
+ f_3__4=labelReg_3__4 f_3__3=labelReg_3__3 f_3__2=labelReg_3__2
+ f_3__1=labelReg_3__1 f_3__0=labelReg_3__0 f_2__15=labelReg_2__15
+ f_2__14=labelReg_2__14 f_2__13=labelReg_2__13 f_2__12=labelReg_2__12
+ f_2__11=labelReg_2__11 f_2__10=labelReg_2__10 f_2__9=labelReg_2__9
+ f_2__8=labelReg_2__8 f_2__7=labelReg_2__7 f_2__6=labelReg_2__6
+ f_2__5=labelReg_2__5 f_2__4=labelReg_2__4 f_2__3=labelReg_2__3
+ f_2__2=labelReg_2__2 f_2__1=labelReg_2__1 f_2__0=labelReg_2__0
+ f_1__15=labelReg_1__15 f_1__14=labelReg_1__14 f_1__13=labelReg_1__13
+ f_1__12=labelReg_1__12 f_1__11=labelReg_1__11 f_1__10=labelReg_1__10
+ f_1__9=labelReg_1__9 f_1__8=labelReg_1__8 f_1__7=labelReg_1__7
+ f_1__6=labelReg_1__6 f_1__5=labelReg_1__5 f_1__4=labelReg_1__4
+ f_1__3=labelReg_1__3 f_1__2=labelReg_1__2 f_1__1=labelReg_1__1
+ f_1__0=labelReg_1__0 f_0__15=labelReg_0__15 f_0__14=labelReg_0__14
+ f_0__13=labelReg_0__13 f_0__12=labelReg_0__12 f_0__11=labelReg_0__11
+ f_0__10=labelReg_0__10 f_0__9=labelReg_0__9 f_0__8=labelReg_0__8
+ f_0__7=labelReg_0__7 f_0__6=labelReg_0__6 f_0__5=labelReg_0__5
+ f_0__4=labelReg_0__4 f_0__3=labelReg_0__3 f_0__2=labelReg_0__2
+ f_0__1=labelReg_0__1 f_0__0=labelReg_0__0 clk=clk start=decrement rst=nx1352
+ done=#dummy[0] working=multiplyWorkIn
XbufferRegOne FlibFlob $PINS D=multiplyWorkIn en=oneNeoron_8 clk=clkInverted
+ rst=reset Q=bufferTwoInput Qbar=#dummy[1]
XbufferRegTwo FlibFlob $PINS D=bufferTwoInput en=oneNeoron_8 clk=clk rst=reset
+ Q=multiplyWorkDelayed Qbar=#dummy[2]
XWeightAddressCounter CounterUpDown_16 $PINS load[15]=oneNeoron_15
+ load[14]=oneNeoron_15 load[13]=oneNeoron_15 load[12]=oneNeoron_15
+ load[11]=oneNeoron_15 load[10]=oneNeoron_15 load[9]=oneNeoron_15
+ load[8]=oneNeoron_15 load[7]=oneNeoron_15 load[6]=oneNeoron_15
+ load[5]=oneNeoron_15 load[4]=oneNeoron_15 load[3]=oneNeoron_15
+ load[2]=oneNeoron_15 load[1]=oneNeoron_15 load[0]=oneNeoron_15
+ resetValue[15]=oneNeoron_15 resetValue[14]=oneNeoron_15
+ resetValue[13]=oneNeoron_15 resetValue[12]=oneNeoron_15
+ resetValue[11]=oneNeoron_15 resetValue[10]=oneNeoron_15
+ resetValue[9]=oneNeoron_15 resetValue[8]=oneNeoron_15
+ resetValue[7]=oneNeoron_15 resetValue[6]=oneNeoron_15
+ resetValue[5]=oneNeoron_15 resetValue[4]=oneNeoron_15
+ resetValue[3]=oneNeoron_15 resetValue[2]=oneNeoron_15
+ resetValue[1]=oneNeoron_15 resetValue[0]=oneNeoron_15 clk=clk
+ en=incrementWeightAdd rst=reset isLoad=nx1318 upOrDown=oneNeoron_15
+ count[15]=dmaAddRamWeights[15] count[14]=dmaAddRamWeights[14]
+ count[13]=dmaAddRamWeights[13] count[12]=dmaAddRamWeights[12]
+ count[11]=dmaAddRamWeights[11] count[10]=dmaAddRamWeights[10]
+ count[9]=dmaAddRamWeights[9] count[8]=dmaAddRamWeights[8]
+ count[7]=dmaAddRamWeights[7] count[6]=dmaAddRamWeights[6]
+ count[5]=dmaAddRamWeights[5] count[4]=dmaAddRamWeights[4]
+ count[3]=dmaAddRamWeights[3] count[2]=dmaAddRamWeights[2]
+ count[1]=dmaAddRamWeights[1] count[0]=dmaAddRamWeights[0]
XNeoronAddressCounter CounterUpDown_13 $PINS load[12]=defaultAddressNeorons[12]
+ load[11]=defaultAddressNeorons[11] load[10]=defaultAddressNeorons[10]
+ load[9]=defaultAddressNeorons[9] load[8]=defaultAddressNeorons[8]
+ load[7]=defaultAddressNeorons[7] load[6]=defaultAddressNeorons[6]
+ load[5]=defaultAddressNeorons[5] load[4]=defaultAddressNeorons[4]
+ load[3]=defaultAddressNeorons[3] load[2]=defaultAddressNeorons[2]
+ load[1]=defaultAddressNeorons[1] load[0]=defaultAddressNeorons[0]
+ resetValue[12]=defaultAddressNeorons[12]
+ resetValue[11]=defaultAddressNeorons[11]
+ resetValue[10]=defaultAddressNeorons[10] resetValue[9]=defaultAddressNeorons[9]
+ resetValue[8]=defaultAddressNeorons[8] resetValue[7]=defaultAddressNeorons[7]
+ resetValue[6]=defaultAddressNeorons[6] resetValue[5]=defaultAddressNeorons[5]
+ resetValue[4]=defaultAddressNeorons[4] resetValue[3]=defaultAddressNeorons[3]
+ resetValue[2]=defaultAddressNeorons[2] resetValue[1]=defaultAddressNeorons[1]
+ resetValue[0]=defaultAddressNeorons[0] clk=clk en=state_8 rst=reset
+ isLoad=nx1352 upOrDown=oneNeoron_15 count[12]=dmaAddRamNeorons[12]
+ count[11]=dmaAddRamNeorons[11] count[10]=dmaAddRamNeorons[10]
+ count[9]=dmaAddRamNeorons[9] count[8]=dmaAddRamNeorons[8]
+ count[7]=dmaAddRamNeorons[7] count[6]=dmaAddRamNeorons[6]
+ count[5]=dmaAddRamNeorons[5] count[4]=dmaAddRamNeorons[4]
+ count[3]=dmaAddRamNeorons[3] count[2]=dmaAddRamNeorons[2]
+ count[1]=dmaAddRamNeorons[1] count[0]=dmaAddRamNeorons[0]
XMAXVALUEREGMAP Reg_4 $PINS D[3]=maxNumber_3 D[2]=maxNumber_2 D[1]=maxNumber_1
+ D[0]=maxNumber_0 en=oneNeoron_8 clk=doneMax rst=reset Q[3]=MAXPrediction[3]
+ Q[2]=MAXPrediction[2] Q[1]=MAXPrediction[1] Q[0]=MAXPrediction[0]
+ Qbar[3]=#dummy[3] Qbar[2]=#dummy[4] Qbar[1]=#dummy[5] Qbar[0]=#dummy[6]
Xix35 oai21 $PINS Y=nx34 A0=finishRamWeights A1=nx1082 B0=nx1084
Xreg_state_1 dffr $PINS Q=state_1 QB=nx1082 D=nx34 CLK=clk R=reset
Xix1085 oai21 $PINS Y=nx1084 A0=state_0 A1=fcDone B0=nx1320
Xreg_state_0 dffs_ni $PINS Q=state_0 QB=#dummy[7] D=nx20 CLK=clk S=reset
Xreg_state_7 dffr $PINS Q=fcDone QB=#dummy[8] D=nx12 CLK=clk R=reset
Xix13 ao22 $PINS Y=nx12 A0=doneMax A1=state_6 B0=nx1144 B1=fcDone
Xreg_state_6 dffr $PINS Q=state_6 QB=#dummy[9] D=nx176 CLK=clk R=reset
Xix177 ao21 $PINS Y=nx176 A0=nx1093 A1=state_6 B0=state_10
Xix1094 inv01 $PINS Y=nx1093 A=doneMax
Xreg_state_10 dffr $PINS Q=state_10 QB=#dummy[10] D=nx166 CLK=clk R=reset
Xix161 or02 $PINS Y=nx160 A0=nx158 A1=decrement
Xix159 nor03_2x $PINS Y=nx158 A0=nx1100 A1=nx1112 A2=nx152
Xix1101 nor03_2x $PINS Y=nx1100 A0=nx1102 A1=finishRamNeorons
+ A2=finishRamWeights
Xix1105 nor04 $PINS Y=nx1104 A0=numberOFNeorons_0 A1=numberOFNeorons_1
+ A2=numberOFNeorons_2 A3=numberOFNeorons_3
Xix1107 nor04 $PINS Y=nx1106 A0=numberOFNeorons_4 A1=numberOFNeorons_5
+ A2=numberOFNeorons_6 A3=numberOFNeorons_7
Xix1109 nor04 $PINS Y=nx1108 A0=numberOFNeorons_8 A1=numberOFNeorons_9
+ A2=numberOFNeorons_10 A3=numberOFNeorons_11
Xix1111 nor04 $PINS Y=nx1110 A0=numberOFNeorons_12 A1=numberOFNeorons_13
+ A2=numberOFNeorons_14 A3=numberOFNeorons_15
Xreg_state_4 dffr $PINS Q=state_4 QB=nx1112 D=nx160 CLK=clk R=reset
Xix153 nor04 $PINS Y=nx152 A0=finishRamNeorons A1=finishRamWeights A2=nx98
+ A3=nx0
Xix99 nand04 $PINS Y=nx98 A0=nx1104 A1=nx1106 A2=nx1108 A3=nx1110
Xix133 or02 $PINS Y=decrement A0=state_8 A1=state_9
Xreg_state_8 dffr $PINS Q=state_8 QB=#dummy[11] D=nx126 CLK=clk R=reset
Xix127 nor02ii $PINS Y=nx126 A0=nx1120 A1=readRamNeorons
Xix1121 nand03 $PINS Y=nx1120 A0=nx1122 A1=finishRamNeorons A2=finishRamWeights
Xix1123 nand02 $PINS Y=nx1122 A0=multiplyWorkIn A1=multiplyWorkDelayed
Xreg_state_5 dffr $PINS Q=readRamNeorons QB=#dummy[12] D=nx120 CLK=clk R=reset
Xix121 ao22 $PINS Y=nx120 A0=readRamNeorons A1=nx1120 B0=state_4 B1=nx106
Xix107 nor03_2x $PINS Y=nx106 A0=nx1102 A1=finishRamNeorons A2=finishRamWeights
Xreg_state_9 dffr $PINS Q=state_9 QB=#dummy[13] D=nx1076 CLK=clk R=reset
Xreg_state_3 dffr $PINS Q=state_3 QB=#dummy[14] D=nx54 CLK=clk R=reset
Xix55 ao22 $PINS Y=nx54 A0=nx1133 A1=state_2 B0=state_3 B1=nx1138
Xix1134 inv01 $PINS Y=nx1133 A=finishRamWeights
Xreg_state_2 dffr $PINS Q=state_2 QB=#dummy[15] D=nx44 CLK=clk R=reset
Xix45 ao21 $PINS Y=nx44 A0=finishRamWeights A1=state_2 B0=nx1326
Xix1139 nand03 $PINS Y=nx1138 A0=nx1122 A1=finishRamWeights A2=state_3
Xix1145 inv01 $PINS Y=nx1144 A=cnnDoneOneCycle
Xix183 or02 $PINS Y=neoronValueSelection A0=state_3 A1=state_9
Xix185 or02 $PINS Y=incrementWeightAdd A0=nx1326 A1=decrement
Xix189 or03 $PINS Y=readRamWeights A0=state_3 A1=readRamNeorons A2=state_1
Xix193 and02 $PINS Y=beginSignal A0=ioDone A1=cnnDone
Xix1152 inv01 $PINS Y=clkInverted A=clk
Xix1103 inv01 $PINS Y=nx1102 A=nx98
Xix65 inv01 $PINS Y=nx1076 A=nx1138
Xix1 inv01 $PINS Y=nx0 A=nx1122
Xix1157 inv01 $PINS Y=nx1158 A=neoronMuxOutput_15
Xix1159 inv01 $PINS Y=nx1160 A=nx1158
Xix1161 inv01 $PINS Y=nx1162 A=nx1158
Xix1163 inv01 $PINS Y=nx1164 A=nx1158
Xix1165 inv01 $PINS Y=nx1166 A=nx1158
Xix1167 inv01 $PINS Y=nx1168 A=neoronMuxOutput_14
Xix1169 inv01 $PINS Y=nx1170 A=nx1168
Xix1171 inv01 $PINS Y=nx1172 A=nx1168
Xix1173 inv01 $PINS Y=nx1174 A=nx1168
Xix1175 inv01 $PINS Y=nx1176 A=nx1168
Xix1177 inv01 $PINS Y=nx1178 A=neoronMuxOutput_13
Xix1179 inv01 $PINS Y=nx1180 A=nx1178
Xix1181 inv01 $PINS Y=nx1182 A=nx1178
Xix1183 inv01 $PINS Y=nx1184 A=nx1178
Xix1185 inv01 $PINS Y=nx1186 A=nx1178
Xix1187 inv01 $PINS Y=nx1188 A=neoronMuxOutput_12
Xix1189 inv01 $PINS Y=nx1190 A=nx1188
Xix1191 inv01 $PINS Y=nx1192 A=nx1188
Xix1193 inv01 $PINS Y=nx1194 A=nx1188
Xix1195 inv01 $PINS Y=nx1196 A=nx1188
Xix1197 inv01 $PINS Y=nx1198 A=neoronMuxOutput_11
Xix1199 inv01 $PINS Y=nx1200 A=nx1198
Xix1201 inv01 $PINS Y=nx1202 A=nx1198
Xix1203 inv01 $PINS Y=nx1204 A=nx1198
Xix1205 inv01 $PINS Y=nx1206 A=nx1198
Xix1207 inv01 $PINS Y=nx1208 A=neoronMuxOutput_10
Xix1209 inv01 $PINS Y=nx1210 A=nx1208
Xix1211 inv01 $PINS Y=nx1212 A=nx1208
Xix1213 inv01 $PINS Y=nx1214 A=nx1208
Xix1215 inv01 $PINS Y=nx1216 A=nx1208
Xix1217 inv01 $PINS Y=nx1218 A=neoronMuxOutput_9
Xix1219 inv01 $PINS Y=nx1220 A=nx1218
Xix1221 inv01 $PINS Y=nx1222 A=nx1218
Xix1223 inv01 $PINS Y=nx1224 A=nx1218
Xix1225 inv01 $PINS Y=nx1226 A=nx1218
Xix1227 inv01 $PINS Y=nx1228 A=neoronMuxOutput_8
Xix1229 inv01 $PINS Y=nx1230 A=nx1228
Xix1231 inv01 $PINS Y=nx1232 A=nx1228
Xix1233 inv01 $PINS Y=nx1234 A=nx1228
Xix1235 inv01 $PINS Y=nx1236 A=nx1228
Xix1237 inv01 $PINS Y=nx1238 A=neoronMuxOutput_7
Xix1239 inv01 $PINS Y=nx1240 A=nx1238
Xix1241 inv01 $PINS Y=nx1242 A=nx1238
Xix1243 inv01 $PINS Y=nx1244 A=nx1238
Xix1245 inv01 $PINS Y=nx1246 A=nx1238
Xix1247 inv01 $PINS Y=nx1248 A=neoronMuxOutput_6
Xix1249 inv01 $PINS Y=nx1250 A=nx1248
Xix1251 inv01 $PINS Y=nx1252 A=nx1248
Xix1253 inv01 $PINS Y=nx1254 A=nx1248
Xix1255 inv01 $PINS Y=nx1256 A=nx1248
Xix1257 inv01 $PINS Y=nx1258 A=neoronMuxOutput_5
Xix1259 inv01 $PINS Y=nx1260 A=nx1258
Xix1261 inv01 $PINS Y=nx1262 A=nx1258
Xix1263 inv01 $PINS Y=nx1264 A=nx1258
Xix1265 inv01 $PINS Y=nx1266 A=nx1258
Xix1267 inv01 $PINS Y=nx1268 A=neoronMuxOutput_4
Xix1269 inv01 $PINS Y=nx1270 A=nx1268
Xix1271 inv01 $PINS Y=nx1272 A=nx1268
Xix1273 inv01 $PINS Y=nx1274 A=nx1268
Xix1275 inv01 $PINS Y=nx1276 A=nx1268
Xix1277 inv01 $PINS Y=nx1278 A=neoronMuxOutput_3
Xix1279 inv01 $PINS Y=nx1280 A=nx1278
Xix1281 inv01 $PINS Y=nx1282 A=nx1278
Xix1283 inv01 $PINS Y=nx1284 A=nx1278
Xix1285 inv01 $PINS Y=nx1286 A=nx1278
Xix1287 inv01 $PINS Y=nx1288 A=neoronMuxOutput_2
Xix1289 inv01 $PINS Y=nx1290 A=nx1288
Xix1291 inv01 $PINS Y=nx1292 A=nx1288
Xix1293 inv01 $PINS Y=nx1294 A=nx1288
Xix1295 inv01 $PINS Y=nx1296 A=nx1288
Xix1297 inv01 $PINS Y=nx1298 A=neoronMuxOutput_1
Xix1299 inv01 $PINS Y=nx1300 A=nx1298
Xix1301 inv01 $PINS Y=nx1302 A=nx1298
Xix1303 inv01 $PINS Y=nx1304 A=nx1298
Xix1305 inv01 $PINS Y=nx1306 A=nx1298
Xix1307 inv01 $PINS Y=nx1308 A=neoronMuxOutput_0
Xix1309 inv01 $PINS Y=nx1310 A=nx1308
Xix1311 inv01 $PINS Y=nx1312 A=nx1308
Xix1313 inv01 $PINS Y=nx1314 A=nx1308
Xix1315 inv01 $PINS Y=nx1316 A=nx1308
Xix1317 inv02 $PINS Y=nx1318 A=nx1144
Xix1319 inv02 $PINS Y=nx1320 A=nx1144
Xix41 nor02ii $PINS Y=loadNumberOFNeorons A0=nx1082 A1=finishRamWeights
Xix21 and02 $PINS Y=nx20 A0=nx1144 A1=state_0
Xix167 nor02ii $PINS Y=nx166 A0=nx1112 A1=nx152
Xix1325 buf02 $PINS Y=nx1326 A=loadNumberOFNeorons
Xix1351 inv02 $PINS Y=nx1352 A=nx1144
.ENDS

.SUBCKT Reg_4 D[3] D[2] D[1] D[0] en clk rst Q[3] Q[2] Q[1] Q[0] Qbar[3]
+ Qbar[2] Qbar[1] Qbar[0]
Xreg_Qbar_0 dffs_ni $PINS Q=Qbar[0] QB=#dummy[0] D=nx186 CLK=nx263 S=rst
Xix187 mux21_ni $PINS Y=nx186 A0=Qbar[0] A1=nx228 S0=en
Xix229 inv01 $PINS Y=nx228 A=D[0]
Xreg_Qbar_1 dffs_ni $PINS Q=Qbar[1] QB=#dummy[1] D=nx196 CLK=nx263 S=rst
Xix197 mux21_ni $PINS Y=nx196 A0=Qbar[1] A1=nx233 S0=en
Xix234 inv01 $PINS Y=nx233 A=D[1]
Xreg_Qbar_2 dffs_ni $PINS Q=Qbar[2] QB=#dummy[2] D=nx206 CLK=nx263 S=rst
Xix207 mux21_ni $PINS Y=nx206 A0=Qbar[2] A1=nx238 S0=en
Xix239 inv01 $PINS Y=nx238 A=D[2]
Xreg_Qbar_3 dffs_ni $PINS Q=Qbar[3] QB=#dummy[3] D=nx216 CLK=nx263 S=rst
Xix217 mux21_ni $PINS Y=nx216 A0=Qbar[3] A1=nx243 S0=en
Xix244 inv01 $PINS Y=nx243 A=D[3]
Xreg_Q_0 dffr $PINS Q=Q[0] QB=#dummy[4] D=nx146 CLK=nx263 R=rst
Xix147 mux21_ni $PINS Y=nx146 A0=Q[0] A1=D[0] S0=en
Xreg_Q_1 dffr $PINS Q=Q[1] QB=#dummy[5] D=nx156 CLK=nx263 R=rst
Xix157 mux21_ni $PINS Y=nx156 A0=Q[1] A1=D[1] S0=en
Xreg_Q_2 dffr $PINS Q=Q[2] QB=#dummy[6] D=nx166 CLK=nx263 R=rst
Xix167 mux21_ni $PINS Y=nx166 A0=Q[2] A1=D[2] S0=en
Xreg_Q_3 dffr $PINS Q=Q[3] QB=#dummy[7] D=nx176 CLK=nx265 R=rst
Xix177 mux21_ni $PINS Y=nx176 A0=Q[3] A1=D[3] S0=en
Xix262 buf02 $PINS Y=nx263 A=clk
Xix264 buf02 $PINS Y=nx265 A=clk
.ENDS

.SUBCKT CounterUpDown_13 load[12] load[11] load[10] load[9] load[8] load[7]
+ load[6] load[5] load[4] load[3] load[2] load[1] load[0] resetValue[12]
+ resetValue[11] resetValue[10] resetValue[9] resetValue[8] resetValue[7]
+ resetValue[6] resetValue[5] resetValue[4] resetValue[3] resetValue[2]
+ resetValue[1] resetValue[0] clk en rst isLoad upOrDown count[12] count[11]
+ count[10] count[9] count[8] count[7] count[6] count[5] count[4] count[3]
+ count[2] count[1] count[0]
XnextCount NBitAdder_13 $PINS a[12]=count[12] a[11]=count[11] a[10]=count[10]
+ a[9]=count[9] a[8]=count[8] a[7]=count[7] a[6]=count[6] a[5]=count[5]
+ a[4]=count[4] a[3]=count[3] a[2]=count[2] a[1]=count[1] a[0]=count[0]
+ b[12]=upOrDown b[11]=upOrDown b[10]=upOrDown b[9]=upOrDown b[8]=upOrDown
+ b[7]=upOrDown b[6]=upOrDown b[5]=upOrDown b[4]=upOrDown b[3]=upOrDown
+ b[2]=upOrDown b[1]=upOrDown b[0]=upOrDown carryIn=NOT_upOrDown
+ sum[12]=countAdded_12 sum[11]=countAdded_11 sum[10]=countAdded_10
+ sum[9]=countAdded_9 sum[8]=countAdded_8 sum[7]=countAdded_7 sum[6]=countAdded_6
+ sum[5]=countAdded_5 sum[4]=countAdded_4 sum[3]=countAdded_3 sum[2]=countAdded_2
+ sum[1]=countAdded_1 sum[0]=countAdded_0 carryOut=#dummy[0]
Xix632 inv01 $PINS Y=NOT_upOrDown A=upOrDown
Xreg_currentCount_0 dffsr_ni $PINS Q=count[0] QB=#dummy[1] D=nx499 CLK=clk
+ S=nx10 R=nx14
Xix500 mux21_ni $PINS Y=nx499 A0=nx8 A1=count[0] S0=nx720
Xix9 mux21_ni $PINS Y=nx8 A0=load[0] A1=countAdded_0 S0=nx732
Xix637 nor02_2x $PINS Y=nx636 A0=nx732 A1=isLoad
Xix11 and02 $PINS Y=nx10 A0=resetValue[0] A1=rst
Xreg_currentCount_1 dffsr_ni $PINS Q=count[1] QB=#dummy[2] D=nx509 CLK=clk
+ S=nx26 R=nx30
Xix510 mux21_ni $PINS Y=nx509 A0=nx24 A1=count[1] S0=nx720
Xix25 mux21_ni $PINS Y=nx24 A0=load[1] A1=countAdded_1 S0=nx732
Xix27 and02 $PINS Y=nx26 A0=resetValue[1] A1=rst
Xreg_currentCount_2 dffsr_ni $PINS Q=count[2] QB=#dummy[3] D=nx519 CLK=clk
+ S=nx42 R=nx46
Xix520 mux21_ni $PINS Y=nx519 A0=nx40 A1=count[2] S0=nx720
Xix41 mux21_ni $PINS Y=nx40 A0=load[2] A1=countAdded_2 S0=nx732
Xix43 and02 $PINS Y=nx42 A0=resetValue[2] A1=rst
Xreg_currentCount_3 dffsr_ni $PINS Q=count[3] QB=#dummy[4] D=nx529 CLK=clk
+ S=nx58 R=nx62
Xix530 mux21_ni $PINS Y=nx529 A0=nx56 A1=count[3] S0=nx720
Xix57 mux21_ni $PINS Y=nx56 A0=load[3] A1=countAdded_3 S0=nx732
Xix59 and02 $PINS Y=nx58 A0=resetValue[3] A1=rst
Xreg_currentCount_4 dffsr_ni $PINS Q=count[4] QB=#dummy[5] D=nx539 CLK=clk
+ S=nx74 R=nx78
Xix540 mux21_ni $PINS Y=nx539 A0=nx72 A1=count[4] S0=nx720
Xix73 mux21_ni $PINS Y=nx72 A0=load[4] A1=countAdded_4 S0=nx732
Xix75 and02 $PINS Y=nx74 A0=resetValue[4] A1=rst
Xreg_currentCount_5 dffsr_ni $PINS Q=count[5] QB=#dummy[6] D=nx549 CLK=clk
+ S=nx90 R=nx94
Xix550 mux21_ni $PINS Y=nx549 A0=nx88 A1=count[5] S0=nx720
Xix89 mux21_ni $PINS Y=nx88 A0=load[5] A1=countAdded_5 S0=nx732
Xix91 and02 $PINS Y=nx90 A0=resetValue[5] A1=rst
Xreg_currentCount_6 dffsr_ni $PINS Q=count[6] QB=#dummy[7] D=nx559 CLK=clk
+ S=nx106 R=nx110
Xix560 mux21_ni $PINS Y=nx559 A0=nx104 A1=count[6] S0=nx720
Xix105 mux21_ni $PINS Y=nx104 A0=load[6] A1=countAdded_6 S0=nx734
Xix107 and02 $PINS Y=nx106 A0=resetValue[6] A1=rst
Xreg_currentCount_7 dffsr_ni $PINS Q=count[7] QB=#dummy[8] D=nx569 CLK=clk
+ S=nx122 R=nx126
Xix570 mux21_ni $PINS Y=nx569 A0=nx120 A1=count[7] S0=nx722
Xix121 mux21_ni $PINS Y=nx120 A0=load[7] A1=countAdded_7 S0=nx734
Xix123 and02 $PINS Y=nx122 A0=resetValue[7] A1=rst
Xreg_currentCount_8 dffsr_ni $PINS Q=count[8] QB=#dummy[9] D=nx579 CLK=clk
+ S=nx138 R=nx142
Xix580 mux21_ni $PINS Y=nx579 A0=nx136 A1=count[8] S0=nx722
Xix137 mux21_ni $PINS Y=nx136 A0=load[8] A1=countAdded_8 S0=nx734
Xix139 and02 $PINS Y=nx138 A0=resetValue[8] A1=rst
Xreg_currentCount_9 dffsr_ni $PINS Q=count[9] QB=#dummy[10] D=nx589 CLK=clk
+ S=nx154 R=nx158
Xix590 mux21_ni $PINS Y=nx589 A0=nx152 A1=count[9] S0=nx722
Xix153 mux21_ni $PINS Y=nx152 A0=load[9] A1=countAdded_9 S0=nx734
Xix155 and02 $PINS Y=nx154 A0=resetValue[9] A1=rst
Xreg_currentCount_10 dffsr_ni $PINS Q=count[10] QB=#dummy[11] D=nx599 CLK=clk
+ S=nx170 R=nx174
Xix600 mux21_ni $PINS Y=nx599 A0=nx168 A1=count[10] S0=nx722
Xix169 mux21_ni $PINS Y=nx168 A0=load[10] A1=countAdded_10 S0=nx734
Xix171 and02 $PINS Y=nx170 A0=resetValue[10] A1=rst
Xreg_currentCount_11 dffsr_ni $PINS Q=count[11] QB=#dummy[12] D=nx609 CLK=clk
+ S=nx186 R=nx190
Xix610 mux21_ni $PINS Y=nx609 A0=nx184 A1=count[11] S0=nx722
Xix185 mux21_ni $PINS Y=nx184 A0=load[11] A1=countAdded_11 S0=nx734
Xix187 and02 $PINS Y=nx186 A0=resetValue[11] A1=rst
Xreg_currentCount_12 dffsr_ni $PINS Q=count[12] QB=#dummy[13] D=nx619 CLK=clk
+ S=nx202 R=nx206
Xix620 mux21_ni $PINS Y=nx619 A0=nx200 A1=count[12] S0=nx722
Xix201 mux21_ni $PINS Y=nx200 A0=load[12] A1=countAdded_12 S0=nx734
Xix203 and02 $PINS Y=nx202 A0=resetValue[12] A1=rst
Xix719 buf02 $PINS Y=nx720 A=nx636
Xix721 buf02 $PINS Y=nx722 A=nx636
Xix15 nor02ii $PINS Y=nx14 A0=resetValue[0] A1=rst
Xix31 nor02ii $PINS Y=nx30 A0=resetValue[1] A1=rst
Xix47 nor02ii $PINS Y=nx46 A0=resetValue[2] A1=rst
Xix63 nor02ii $PINS Y=nx62 A0=resetValue[3] A1=rst
Xix79 nor02ii $PINS Y=nx78 A0=resetValue[4] A1=rst
Xix95 nor02ii $PINS Y=nx94 A0=resetValue[5] A1=rst
Xix111 nor02ii $PINS Y=nx110 A0=resetValue[6] A1=rst
Xix127 nor02ii $PINS Y=nx126 A0=resetValue[7] A1=rst
Xix143 nor02ii $PINS Y=nx142 A0=resetValue[8] A1=rst
Xix159 nor02ii $PINS Y=nx158 A0=resetValue[9] A1=rst
Xix175 nor02ii $PINS Y=nx174 A0=resetValue[10] A1=rst
Xix191 nor02ii $PINS Y=nx190 A0=resetValue[11] A1=rst
Xix207 nor02ii $PINS Y=nx206 A0=resetValue[12] A1=rst
Xix731 buf02 $PINS Y=nx732 A=en
Xix733 buf02 $PINS Y=nx734 A=en
.ENDS

.SUBCKT NBitAdder_13 a[12] a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2]
+ a[1] a[0] b[12] b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2] b[1] b[0]
+ carryIn sum[12] sum[11] sum[10] sum[9] sum[8] sum[7] sum[6] sum[5] sum[4]
+ sum[3] sum[2] sum[1] sum[0] carryOut
Xf0 FullAdder $PINS a=a[0] b=b[0] cin=carryIn s=sum[0] cout=temp_0
Xloop1_1_fx FullAdder $PINS a=a[1] b=b[1] cin=temp_0 s=sum[1] cout=temp_1
Xloop1_2_fx FullAdder $PINS a=a[2] b=b[2] cin=temp_1 s=sum[2] cout=temp_2
Xloop1_3_fx FullAdder $PINS a=a[3] b=b[3] cin=temp_2 s=sum[3] cout=temp_3
Xloop1_4_fx FullAdder $PINS a=a[4] b=b[4] cin=temp_3 s=sum[4] cout=temp_4
Xloop1_5_fx FullAdder $PINS a=a[5] b=b[5] cin=temp_4 s=sum[5] cout=temp_5
Xloop1_6_fx FullAdder $PINS a=a[6] b=b[6] cin=temp_5 s=sum[6] cout=temp_6
Xloop1_7_fx FullAdder $PINS a=a[7] b=b[7] cin=temp_6 s=sum[7] cout=temp_7
Xloop1_8_fx FullAdder $PINS a=a[8] b=b[8] cin=temp_7 s=sum[8] cout=temp_8
Xloop1_9_fx FullAdder $PINS a=a[9] b=b[9] cin=temp_8 s=sum[9] cout=temp_9
Xloop1_10_fx FullAdder $PINS a=a[10] b=b[10] cin=temp_9 s=sum[10] cout=temp_10
Xloop1_11_fx FullAdder $PINS a=a[11] b=b[11] cin=temp_10 s=sum[11] cout=temp_11
Xloop1_12_fx FullAdder $PINS a=a[12] b=b[12] cin=temp_11 s=sum[12]
+ cout=carryOut
.ENDS

.SUBCKT FlibFlob D en clk rst Q Qbar
Xreg_Qbar dffs_ni $PINS Q=Qbar QB=#dummy[0] D=nx75 CLK=clk S=rst
Xix76 mux21_ni $PINS Y=nx75 A0=Qbar A1=nx87 S0=en
Xix88 inv01 $PINS Y=nx87 A=D
Xreg_Q dffr $PINS Q=Q QB=#dummy[1] D=nx65 CLK=clk R=rst
Xix66 mux21_ni $PINS Y=nx65 A0=Q A1=D S0=en
.ENDS

.SUBCKT Alus8x16_10 q_9__7 q_9__6 q_9__5 q_9__4 q_9__3 q_9__2 q_9__1 q_9__0
+ q_8__7 q_8__6 q_8__5 q_8__4 q_8__3 q_8__2 q_8__1 q_8__0 q_7__7 q_7__6 q_7__5
+ q_7__4 q_7__3 q_7__2 q_7__1 q_7__0 q_6__7 q_6__6 q_6__5 q_6__4 q_6__3 q_6__2
+ q_6__1 q_6__0 q_5__7 q_5__6 q_5__5 q_5__4 q_5__3 q_5__2 q_5__1 q_5__0 q_4__7
+ q_4__6 q_4__5 q_4__4 q_4__3 q_4__2 q_4__1 q_4__0 q_3__7 q_3__6 q_3__5 q_3__4
+ q_3__3 q_3__2 q_3__1 q_3__0 q_2__7 q_2__6 q_2__5 q_2__4 q_2__3 q_2__2 q_2__1
+ q_2__0 q_1__7 q_1__6 q_1__5 q_1__4 q_1__3 q_1__2 q_1__1 q_1__0 q_0__7 q_0__6
+ q_0__5 q_0__4 q_0__3 q_0__2 q_0__1 q_0__0 m_9__15 m_9__14 m_9__13 m_9__12
+ m_9__11 m_9__10 m_9__9 m_9__8 m_9__7 m_9__6 m_9__5 m_9__4 m_9__3 m_9__2
+ m_9__1 m_9__0 m_8__15 m_8__14 m_8__13 m_8__12 m_8__11 m_8__10 m_8__9 m_8__8
+ m_8__7 m_8__6 m_8__5 m_8__4 m_8__3 m_8__2 m_8__1 m_8__0 m_7__15 m_7__14
+ m_7__13 m_7__12 m_7__11 m_7__10 m_7__9 m_7__8 m_7__7 m_7__6 m_7__5 m_7__4
+ m_7__3 m_7__2 m_7__1 m_7__0 m_6__15 m_6__14 m_6__13 m_6__12 m_6__11 m_6__10
+ m_6__9 m_6__8 m_6__7 m_6__6 m_6__5 m_6__4 m_6__3 m_6__2 m_6__1 m_6__0 m_5__15
+ m_5__14 m_5__13 m_5__12 m_5__11 m_5__10 m_5__9 m_5__8 m_5__7 m_5__6 m_5__5
+ m_5__4 m_5__3 m_5__2 m_5__1 m_5__0 m_4__15 m_4__14 m_4__13 m_4__12 m_4__11
+ m_4__10 m_4__9 m_4__8 m_4__7 m_4__6 m_4__5 m_4__4 m_4__3 m_4__2 m_4__1 m_4__0
+ m_3__15 m_3__14 m_3__13 m_3__12 m_3__11 m_3__10 m_3__9 m_3__8 m_3__7 m_3__6
+ m_3__5 m_3__4 m_3__3 m_3__2 m_3__1 m_3__0 m_2__15 m_2__14 m_2__13 m_2__12
+ m_2__11 m_2__10 m_2__9 m_2__8 m_2__7 m_2__6 m_2__5 m_2__4 m_2__3 m_2__2
+ m_2__1 m_2__0 m_1__15 m_1__14 m_1__13 m_1__12 m_1__11 m_1__10 m_1__9 m_1__8
+ m_1__7 m_1__6 m_1__5 m_1__4 m_1__3 m_1__2 m_1__1 m_1__0 m_0__15 m_0__14
+ m_0__13 m_0__12 m_0__11 m_0__10 m_0__9 m_0__8 m_0__7 m_0__6 m_0__5 m_0__4
+ m_0__3 m_0__2 m_0__1 m_0__0 f_9__15 f_9__14 f_9__13 f_9__12 f_9__11 f_9__10
+ f_9__9 f_9__8 f_9__7 f_9__6 f_9__5 f_9__4 f_9__3 f_9__2 f_9__1 f_9__0 f_8__15
+ f_8__14 f_8__13 f_8__12 f_8__11 f_8__10 f_8__9 f_8__8 f_8__7 f_8__6 f_8__5
+ f_8__4 f_8__3 f_8__2 f_8__1 f_8__0 f_7__15 f_7__14 f_7__13 f_7__12 f_7__11
+ f_7__10 f_7__9 f_7__8 f_7__7 f_7__6 f_7__5 f_7__4 f_7__3 f_7__2 f_7__1 f_7__0
+ f_6__15 f_6__14 f_6__13 f_6__12 f_6__11 f_6__10 f_6__9 f_6__8 f_6__7 f_6__6
+ f_6__5 f_6__4 f_6__3 f_6__2 f_6__1 f_6__0 f_5__15 f_5__14 f_5__13 f_5__12
+ f_5__11 f_5__10 f_5__9 f_5__8 f_5__7 f_5__6 f_5__5 f_5__4 f_5__3 f_5__2
+ f_5__1 f_5__0 f_4__15 f_4__14 f_4__13 f_4__12 f_4__11 f_4__10 f_4__9 f_4__8
+ f_4__7 f_4__6 f_4__5 f_4__4 f_4__3 f_4__2 f_4__1 f_4__0 f_3__15 f_3__14
+ f_3__13 f_3__12 f_3__11 f_3__10 f_3__9 f_3__8 f_3__7 f_3__6 f_3__5 f_3__4
+ f_3__3 f_3__2 f_3__1 f_3__0 f_2__15 f_2__14 f_2__13 f_2__12 f_2__11 f_2__10
+ f_2__9 f_2__8 f_2__7 f_2__6 f_2__5 f_2__4 f_2__3 f_2__2 f_2__1 f_2__0 f_1__15
+ f_1__14 f_1__13 f_1__12 f_1__11 f_1__10 f_1__9 f_1__8 f_1__7 f_1__6 f_1__5
+ f_1__4 f_1__3 f_1__2 f_1__1 f_1__0 f_0__15 f_0__14 f_0__13 f_0__12 f_0__11
+ f_0__10 f_0__9 f_0__8 f_0__7 f_0__6 f_0__5 f_0__4 f_0__3 f_0__2 f_0__1 f_0__0
+ clk start rst done working
Xcmp1 nMul8x16_10 $PINS q_9__7=q_9__7 q_9__6=q_9__6 q_9__5=q_9__5 q_9__4=q_9__4
+ q_9__3=q_9__3 q_9__2=q_9__2 q_9__1=q_9__1 q_9__0=q_9__0 q_8__7=q_8__7
+ q_8__6=q_8__6 q_8__5=q_8__5 q_8__4=q_8__4 q_8__3=q_8__3 q_8__2=q_8__2
+ q_8__1=q_8__1 q_8__0=q_8__0 q_7__7=q_7__7 q_7__6=q_7__6 q_7__5=q_7__5
+ q_7__4=q_7__4 q_7__3=q_7__3 q_7__2=q_7__2 q_7__1=q_7__1 q_7__0=q_7__0
+ q_6__7=q_6__7 q_6__6=q_6__6 q_6__5=q_6__5 q_6__4=q_6__4 q_6__3=q_6__3
+ q_6__2=q_6__2 q_6__1=q_6__1 q_6__0=q_6__0 q_5__7=q_5__7 q_5__6=q_5__6
+ q_5__5=q_5__5 q_5__4=q_5__4 q_5__3=q_5__3 q_5__2=q_5__2 q_5__1=q_5__1
+ q_5__0=q_5__0 q_4__7=q_4__7 q_4__6=q_4__6 q_4__5=q_4__5 q_4__4=q_4__4
+ q_4__3=q_4__3 q_4__2=q_4__2 q_4__1=q_4__1 q_4__0=q_4__0 q_3__7=q_3__7
+ q_3__6=q_3__6 q_3__5=q_3__5 q_3__4=q_3__4 q_3__3=q_3__3 q_3__2=q_3__2
+ q_3__1=q_3__1 q_3__0=q_3__0 q_2__7=q_2__7 q_2__6=q_2__6 q_2__5=q_2__5
+ q_2__4=q_2__4 q_2__3=q_2__3 q_2__2=q_2__2 q_2__1=q_2__1 q_2__0=q_2__0
+ q_1__7=q_1__7 q_1__6=q_1__6 q_1__5=q_1__5 q_1__4=q_1__4 q_1__3=q_1__3
+ q_1__2=q_1__2 q_1__1=q_1__1 q_1__0=q_1__0 q_0__7=q_0__7 q_0__6=q_0__6
+ q_0__5=q_0__5 q_0__4=q_0__4 q_0__3=q_0__3 q_0__2=q_0__2 q_0__1=q_0__1
+ q_0__0=q_0__0 m_9__15=m_9__15 m_9__14=m_9__14 m_9__13=m_9__13 m_9__12=m_9__12
+ m_9__11=m_9__11 m_9__10=m_9__10 m_9__9=m_9__9 m_9__8=m_9__8 m_9__7=m_9__7
+ m_9__6=m_9__6 m_9__5=m_9__5 m_9__4=m_9__4 m_9__3=m_9__3 m_9__2=m_9__2
+ m_9__1=m_9__1 m_9__0=m_9__0 m_8__15=m_8__15 m_8__14=m_8__14 m_8__13=m_8__13
+ m_8__12=m_8__12 m_8__11=m_8__11 m_8__10=m_8__10 m_8__9=m_8__9 m_8__8=m_8__8
+ m_8__7=m_8__7 m_8__6=m_8__6 m_8__5=m_8__5 m_8__4=m_8__4 m_8__3=m_8__3
+ m_8__2=m_8__2 m_8__1=m_8__1 m_8__0=m_8__0 m_7__15=m_7__15 m_7__14=m_7__14
+ m_7__13=m_7__13 m_7__12=m_7__12 m_7__11=m_7__11 m_7__10=m_7__10 m_7__9=m_7__9
+ m_7__8=m_7__8 m_7__7=m_7__7 m_7__6=m_7__6 m_7__5=m_7__5 m_7__4=m_7__4
+ m_7__3=m_7__3 m_7__2=m_7__2 m_7__1=m_7__1 m_7__0=m_7__0 m_6__15=m_6__15
+ m_6__14=m_6__14 m_6__13=m_6__13 m_6__12=m_6__12 m_6__11=m_6__11 m_6__10=m_6__10
+ m_6__9=m_6__9 m_6__8=m_6__8 m_6__7=m_6__7 m_6__6=m_6__6 m_6__5=m_6__5
+ m_6__4=m_6__4 m_6__3=m_6__3 m_6__2=m_6__2 m_6__1=m_6__1 m_6__0=m_6__0
+ m_5__15=m_5__15 m_5__14=m_5__14 m_5__13=m_5__13 m_5__12=m_5__12 m_5__11=m_5__11
+ m_5__10=m_5__10 m_5__9=m_5__9 m_5__8=m_5__8 m_5__7=m_5__7 m_5__6=m_5__6
+ m_5__5=m_5__5 m_5__4=m_5__4 m_5__3=m_5__3 m_5__2=m_5__2 m_5__1=m_5__1
+ m_5__0=m_5__0 m_4__15=m_4__15 m_4__14=m_4__14 m_4__13=m_4__13 m_4__12=m_4__12
+ m_4__11=m_4__11 m_4__10=m_4__10 m_4__9=m_4__9 m_4__8=m_4__8 m_4__7=m_4__7
+ m_4__6=m_4__6 m_4__5=m_4__5 m_4__4=m_4__4 m_4__3=m_4__3 m_4__2=m_4__2
+ m_4__1=m_4__1 m_4__0=m_4__0 m_3__15=m_3__15 m_3__14=m_3__14 m_3__13=m_3__13
+ m_3__12=m_3__12 m_3__11=m_3__11 m_3__10=m_3__10 m_3__9=m_3__9 m_3__8=m_3__8
+ m_3__7=m_3__7 m_3__6=m_3__6 m_3__5=m_3__5 m_3__4=m_3__4 m_3__3=m_3__3
+ m_3__2=m_3__2 m_3__1=m_3__1 m_3__0=m_3__0 m_2__15=m_2__15 m_2__14=m_2__14
+ m_2__13=m_2__13 m_2__12=m_2__12 m_2__11=m_2__11 m_2__10=m_2__10 m_2__9=m_2__9
+ m_2__8=m_2__8 m_2__7=m_2__7 m_2__6=m_2__6 m_2__5=m_2__5 m_2__4=m_2__4
+ m_2__3=m_2__3 m_2__2=m_2__2 m_2__1=m_2__1 m_2__0=m_2__0 m_1__15=m_1__15
+ m_1__14=m_1__14 m_1__13=m_1__13 m_1__12=m_1__12 m_1__11=m_1__11 m_1__10=m_1__10
+ m_1__9=m_1__9 m_1__8=m_1__8 m_1__7=m_1__7 m_1__6=m_1__6 m_1__5=m_1__5
+ m_1__4=m_1__4 m_1__3=m_1__3 m_1__2=m_1__2 m_1__1=m_1__1 m_1__0=m_1__0
+ m_0__15=m_0__15 m_0__14=m_0__14 m_0__13=m_0__13 m_0__12=m_0__12 m_0__11=m_0__11
+ m_0__10=m_0__10 m_0__9=m_0__9 m_0__8=m_0__8 m_0__7=m_0__7 m_0__6=m_0__6
+ m_0__5=m_0__5 m_0__4=m_0__4 m_0__3=m_0__3 m_0__2=m_0__2 m_0__1=m_0__1
+ m_0__0=m_0__0 f_9__15=mulOut_9__15 f_9__14=mulOut_9__14 f_9__13=mulOut_9__13
+ f_9__12=mulOut_9__12 f_9__11=mulOut_9__11 f_9__10=mulOut_9__10
+ f_9__9=mulOut_9__9 f_9__8=mulOut_9__8 f_9__7=mulOut_9__7 f_9__6=mulOut_9__6
+ f_9__5=mulOut_9__5 f_9__4=mulOut_9__4 f_9__3=mulOut_9__3 f_9__2=mulOut_9__2
+ f_9__1=mulOut_9__1 f_9__0=mulOut_9__0 f_8__15=mulOut_8__15 f_8__14=mulOut_8__14
+ f_8__13=mulOut_8__13 f_8__12=mulOut_8__12 f_8__11=mulOut_8__11
+ f_8__10=mulOut_8__10 f_8__9=mulOut_8__9 f_8__8=mulOut_8__8 f_8__7=mulOut_8__7
+ f_8__6=mulOut_8__6 f_8__5=mulOut_8__5 f_8__4=mulOut_8__4 f_8__3=mulOut_8__3
+ f_8__2=mulOut_8__2 f_8__1=mulOut_8__1 f_8__0=mulOut_8__0 f_7__15=mulOut_7__15
+ f_7__14=mulOut_7__14 f_7__13=mulOut_7__13 f_7__12=mulOut_7__12
+ f_7__11=mulOut_7__11 f_7__10=mulOut_7__10 f_7__9=mulOut_7__9 f_7__8=mulOut_7__8
+ f_7__7=mulOut_7__7 f_7__6=mulOut_7__6 f_7__5=mulOut_7__5 f_7__4=mulOut_7__4
+ f_7__3=mulOut_7__3 f_7__2=mulOut_7__2 f_7__1=mulOut_7__1 f_7__0=mulOut_7__0
+ f_6__15=mulOut_6__15 f_6__14=mulOut_6__14 f_6__13=mulOut_6__13
+ f_6__12=mulOut_6__12 f_6__11=mulOut_6__11 f_6__10=mulOut_6__10
+ f_6__9=mulOut_6__9 f_6__8=mulOut_6__8 f_6__7=mulOut_6__7 f_6__6=mulOut_6__6
+ f_6__5=mulOut_6__5 f_6__4=mulOut_6__4 f_6__3=mulOut_6__3 f_6__2=mulOut_6__2
+ f_6__1=mulOut_6__1 f_6__0=mulOut_6__0 f_5__15=mulOut_5__15 f_5__14=mulOut_5__14
+ f_5__13=mulOut_5__13 f_5__12=mulOut_5__12 f_5__11=mulOut_5__11
+ f_5__10=mulOut_5__10 f_5__9=mulOut_5__9 f_5__8=mulOut_5__8 f_5__7=mulOut_5__7
+ f_5__6=mulOut_5__6 f_5__5=mulOut_5__5 f_5__4=mulOut_5__4 f_5__3=mulOut_5__3
+ f_5__2=mulOut_5__2 f_5__1=mulOut_5__1 f_5__0=mulOut_5__0 f_4__15=mulOut_4__15
+ f_4__14=mulOut_4__14 f_4__13=mulOut_4__13 f_4__12=mulOut_4__12
+ f_4__11=mulOut_4__11 f_4__10=mulOut_4__10 f_4__9=mulOut_4__9 f_4__8=mulOut_4__8
+ f_4__7=mulOut_4__7 f_4__6=mulOut_4__6 f_4__5=mulOut_4__5 f_4__4=mulOut_4__4
+ f_4__3=mulOut_4__3 f_4__2=mulOut_4__2 f_4__1=mulOut_4__1 f_4__0=mulOut_4__0
+ f_3__15=mulOut_3__15 f_3__14=mulOut_3__14 f_3__13=mulOut_3__13
+ f_3__12=mulOut_3__12 f_3__11=mulOut_3__11 f_3__10=mulOut_3__10
+ f_3__9=mulOut_3__9 f_3__8=mulOut_3__8 f_3__7=mulOut_3__7 f_3__6=mulOut_3__6
+ f_3__5=mulOut_3__5 f_3__4=mulOut_3__4 f_3__3=mulOut_3__3 f_3__2=mulOut_3__2
+ f_3__1=mulOut_3__1 f_3__0=mulOut_3__0 f_2__15=mulOut_2__15 f_2__14=mulOut_2__14
+ f_2__13=mulOut_2__13 f_2__12=mulOut_2__12 f_2__11=mulOut_2__11
+ f_2__10=mulOut_2__10 f_2__9=mulOut_2__9 f_2__8=mulOut_2__8 f_2__7=mulOut_2__7
+ f_2__6=mulOut_2__6 f_2__5=mulOut_2__5 f_2__4=mulOut_2__4 f_2__3=mulOut_2__3
+ f_2__2=mulOut_2__2 f_2__1=mulOut_2__1 f_2__0=mulOut_2__0 f_1__15=mulOut_1__15
+ f_1__14=mulOut_1__14 f_1__13=mulOut_1__13 f_1__12=mulOut_1__12
+ f_1__11=mulOut_1__11 f_1__10=mulOut_1__10 f_1__9=mulOut_1__9 f_1__8=mulOut_1__8
+ f_1__7=mulOut_1__7 f_1__6=mulOut_1__6 f_1__5=mulOut_1__5 f_1__4=mulOut_1__4
+ f_1__3=mulOut_1__3 f_1__2=mulOut_1__2 f_1__1=mulOut_1__1 f_1__0=mulOut_1__0
+ f_0__15=mulOut_0__15 f_0__14=mulOut_0__14 f_0__13=mulOut_0__13
+ f_0__12=mulOut_0__12 f_0__11=mulOut_0__11 f_0__10=mulOut_0__10
+ f_0__9=mulOut_0__9 f_0__8=mulOut_0__8 f_0__7=mulOut_0__7 f_0__6=mulOut_0__6
+ f_0__5=mulOut_0__5 f_0__4=mulOut_0__4 f_0__3=mulOut_0__3 f_0__2=mulOut_0__2
+ f_0__1=mulOut_0__1 f_0__0=mulOut_0__0 clk=clk start=start rst=rst done=done
+ working=working
Xcmp2 Accumulator_10 $PINS a_9__15=mulOut_9__15 a_9__14=mulOut_9__14
+ a_9__13=mulOut_9__13 a_9__12=mulOut_9__12 a_9__11=mulOut_9__11
+ a_9__10=mulOut_9__10 a_9__9=mulOut_9__9 a_9__8=mulOut_9__8 a_9__7=mulOut_9__7
+ a_9__6=mulOut_9__6 a_9__5=mulOut_9__5 a_9__4=mulOut_9__4 a_9__3=mulOut_9__3
+ a_9__2=mulOut_9__2 a_9__1=mulOut_9__1 a_9__0=mulOut_9__0 a_8__15=mulOut_8__15
+ a_8__14=mulOut_8__14 a_8__13=mulOut_8__13 a_8__12=mulOut_8__12
+ a_8__11=mulOut_8__11 a_8__10=mulOut_8__10 a_8__9=mulOut_8__9 a_8__8=mulOut_8__8
+ a_8__7=mulOut_8__7 a_8__6=mulOut_8__6 a_8__5=mulOut_8__5 a_8__4=mulOut_8__4
+ a_8__3=mulOut_8__3 a_8__2=mulOut_8__2 a_8__1=mulOut_8__1 a_8__0=mulOut_8__0
+ a_7__15=mulOut_7__15 a_7__14=mulOut_7__14 a_7__13=mulOut_7__13
+ a_7__12=mulOut_7__12 a_7__11=mulOut_7__11 a_7__10=mulOut_7__10
+ a_7__9=mulOut_7__9 a_7__8=mulOut_7__8 a_7__7=mulOut_7__7 a_7__6=mulOut_7__6
+ a_7__5=mulOut_7__5 a_7__4=mulOut_7__4 a_7__3=mulOut_7__3 a_7__2=mulOut_7__2
+ a_7__1=mulOut_7__1 a_7__0=mulOut_7__0 a_6__15=mulOut_6__15 a_6__14=mulOut_6__14
+ a_6__13=mulOut_6__13 a_6__12=mulOut_6__12 a_6__11=mulOut_6__11
+ a_6__10=mulOut_6__10 a_6__9=mulOut_6__9 a_6__8=mulOut_6__8 a_6__7=mulOut_6__7
+ a_6__6=mulOut_6__6 a_6__5=mulOut_6__5 a_6__4=mulOut_6__4 a_6__3=mulOut_6__3
+ a_6__2=mulOut_6__2 a_6__1=mulOut_6__1 a_6__0=mulOut_6__0 a_5__15=mulOut_5__15
+ a_5__14=mulOut_5__14 a_5__13=mulOut_5__13 a_5__12=mulOut_5__12
+ a_5__11=mulOut_5__11 a_5__10=mulOut_5__10 a_5__9=mulOut_5__9 a_5__8=mulOut_5__8
+ a_5__7=mulOut_5__7 a_5__6=mulOut_5__6 a_5__5=mulOut_5__5 a_5__4=mulOut_5__4
+ a_5__3=mulOut_5__3 a_5__2=mulOut_5__2 a_5__1=mulOut_5__1 a_5__0=mulOut_5__0
+ a_4__15=mulOut_4__15 a_4__14=mulOut_4__14 a_4__13=mulOut_4__13
+ a_4__12=mulOut_4__12 a_4__11=mulOut_4__11 a_4__10=mulOut_4__10
+ a_4__9=mulOut_4__9 a_4__8=mulOut_4__8 a_4__7=mulOut_4__7 a_4__6=mulOut_4__6
+ a_4__5=mulOut_4__5 a_4__4=mulOut_4__4 a_4__3=mulOut_4__3 a_4__2=mulOut_4__2
+ a_4__1=mulOut_4__1 a_4__0=mulOut_4__0 a_3__15=mulOut_3__15 a_3__14=mulOut_3__14
+ a_3__13=mulOut_3__13 a_3__12=mulOut_3__12 a_3__11=mulOut_3__11
+ a_3__10=mulOut_3__10 a_3__9=mulOut_3__9 a_3__8=mulOut_3__8 a_3__7=mulOut_3__7
+ a_3__6=mulOut_3__6 a_3__5=mulOut_3__5 a_3__4=mulOut_3__4 a_3__3=mulOut_3__3
+ a_3__2=mulOut_3__2 a_3__1=mulOut_3__1 a_3__0=mulOut_3__0 a_2__15=mulOut_2__15
+ a_2__14=mulOut_2__14 a_2__13=mulOut_2__13 a_2__12=mulOut_2__12
+ a_2__11=mulOut_2__11 a_2__10=mulOut_2__10 a_2__9=mulOut_2__9 a_2__8=mulOut_2__8
+ a_2__7=mulOut_2__7 a_2__6=mulOut_2__6 a_2__5=mulOut_2__5 a_2__4=mulOut_2__4
+ a_2__3=mulOut_2__3 a_2__2=mulOut_2__2 a_2__1=mulOut_2__1 a_2__0=mulOut_2__0
+ a_1__15=mulOut_1__15 a_1__14=mulOut_1__14 a_1__13=mulOut_1__13
+ a_1__12=mulOut_1__12 a_1__11=mulOut_1__11 a_1__10=mulOut_1__10
+ a_1__9=mulOut_1__9 a_1__8=mulOut_1__8 a_1__7=mulOut_1__7 a_1__6=mulOut_1__6
+ a_1__5=mulOut_1__5 a_1__4=mulOut_1__4 a_1__3=mulOut_1__3 a_1__2=mulOut_1__2
+ a_1__1=mulOut_1__1 a_1__0=mulOut_1__0 a_0__15=mulOut_0__15 a_0__14=mulOut_0__14
+ a_0__13=mulOut_0__13 a_0__12=mulOut_0__12 a_0__11=mulOut_0__11
+ a_0__10=mulOut_0__10 a_0__9=mulOut_0__9 a_0__8=mulOut_0__8 a_0__7=mulOut_0__7
+ a_0__6=mulOut_0__6 a_0__5=mulOut_0__5 a_0__4=mulOut_0__4 a_0__3=mulOut_0__3
+ a_0__2=mulOut_0__2 a_0__1=mulOut_0__1 a_0__0=mulOut_0__0 f_9__15=f_9__15
+ f_9__14=f_9__14 f_9__13=f_9__13 f_9__12=f_9__12 f_9__11=f_9__11 f_9__10=f_9__10
+ f_9__9=f_9__9 f_9__8=f_9__8 f_9__7=f_9__7 f_9__6=f_9__6 f_9__5=f_9__5
+ f_9__4=f_9__4 f_9__3=f_9__3 f_9__2=f_9__2 f_9__1=f_9__1 f_9__0=f_9__0
+ f_8__15=f_8__15 f_8__14=f_8__14 f_8__13=f_8__13 f_8__12=f_8__12 f_8__11=f_8__11
+ f_8__10=f_8__10 f_8__9=f_8__9 f_8__8=f_8__8 f_8__7=f_8__7 f_8__6=f_8__6
+ f_8__5=f_8__5 f_8__4=f_8__4 f_8__3=f_8__3 f_8__2=f_8__2 f_8__1=f_8__1
+ f_8__0=f_8__0 f_7__15=f_7__15 f_7__14=f_7__14 f_7__13=f_7__13 f_7__12=f_7__12
+ f_7__11=f_7__11 f_7__10=f_7__10 f_7__9=f_7__9 f_7__8=f_7__8 f_7__7=f_7__7
+ f_7__6=f_7__6 f_7__5=f_7__5 f_7__4=f_7__4 f_7__3=f_7__3 f_7__2=f_7__2
+ f_7__1=f_7__1 f_7__0=f_7__0 f_6__15=f_6__15 f_6__14=f_6__14 f_6__13=f_6__13
+ f_6__12=f_6__12 f_6__11=f_6__11 f_6__10=f_6__10 f_6__9=f_6__9 f_6__8=f_6__8
+ f_6__7=f_6__7 f_6__6=f_6__6 f_6__5=f_6__5 f_6__4=f_6__4 f_6__3=f_6__3
+ f_6__2=f_6__2 f_6__1=f_6__1 f_6__0=f_6__0 f_5__15=f_5__15 f_5__14=f_5__14
+ f_5__13=f_5__13 f_5__12=f_5__12 f_5__11=f_5__11 f_5__10=f_5__10 f_5__9=f_5__9
+ f_5__8=f_5__8 f_5__7=f_5__7 f_5__6=f_5__6 f_5__5=f_5__5 f_5__4=f_5__4
+ f_5__3=f_5__3 f_5__2=f_5__2 f_5__1=f_5__1 f_5__0=f_5__0 f_4__15=f_4__15
+ f_4__14=f_4__14 f_4__13=f_4__13 f_4__12=f_4__12 f_4__11=f_4__11 f_4__10=f_4__10
+ f_4__9=f_4__9 f_4__8=f_4__8 f_4__7=f_4__7 f_4__6=f_4__6 f_4__5=f_4__5
+ f_4__4=f_4__4 f_4__3=f_4__3 f_4__2=f_4__2 f_4__1=f_4__1 f_4__0=f_4__0
+ f_3__15=f_3__15 f_3__14=f_3__14 f_3__13=f_3__13 f_3__12=f_3__12 f_3__11=f_3__11
+ f_3__10=f_3__10 f_3__9=f_3__9 f_3__8=f_3__8 f_3__7=f_3__7 f_3__6=f_3__6
+ f_3__5=f_3__5 f_3__4=f_3__4 f_3__3=f_3__3 f_3__2=f_3__2 f_3__1=f_3__1
+ f_3__0=f_3__0 f_2__15=f_2__15 f_2__14=f_2__14 f_2__13=f_2__13 f_2__12=f_2__12
+ f_2__11=f_2__11 f_2__10=f_2__10 f_2__9=f_2__9 f_2__8=f_2__8 f_2__7=f_2__7
+ f_2__6=f_2__6 f_2__5=f_2__5 f_2__4=f_2__4 f_2__3=f_2__3 f_2__2=f_2__2
+ f_2__1=f_2__1 f_2__0=f_2__0 f_1__15=f_1__15 f_1__14=f_1__14 f_1__13=f_1__13
+ f_1__12=f_1__12 f_1__11=f_1__11 f_1__10=f_1__10 f_1__9=f_1__9 f_1__8=f_1__8
+ f_1__7=f_1__7 f_1__6=f_1__6 f_1__5=f_1__5 f_1__4=f_1__4 f_1__3=f_1__3
+ f_1__2=f_1__2 f_1__1=f_1__1 f_1__0=f_1__0 f_0__15=f_0__15 f_0__14=f_0__14
+ f_0__13=f_0__13 f_0__12=f_0__12 f_0__11=f_0__11 f_0__10=f_0__10 f_0__9=f_0__9
+ f_0__8=f_0__8 f_0__7=f_0__7 f_0__6=f_0__6 f_0__5=f_0__5 f_0__4=f_0__4
+ f_0__3=f_0__3 f_0__2=f_0__2 f_0__1=f_0__1 f_0__0=f_0__0 save=working rst=rst
.ENDS

.SUBCKT Accumulator_10 a_9__15 a_9__14 a_9__13 a_9__12 a_9__11 a_9__10 a_9__9
+ a_9__8 a_9__7 a_9__6 a_9__5 a_9__4 a_9__3 a_9__2 a_9__1 a_9__0 a_8__15
+ a_8__14 a_8__13 a_8__12 a_8__11 a_8__10 a_8__9 a_8__8 a_8__7 a_8__6 a_8__5
+ a_8__4 a_8__3 a_8__2 a_8__1 a_8__0 a_7__15 a_7__14 a_7__13 a_7__12 a_7__11
+ a_7__10 a_7__9 a_7__8 a_7__7 a_7__6 a_7__5 a_7__4 a_7__3 a_7__2 a_7__1 a_7__0
+ a_6__15 a_6__14 a_6__13 a_6__12 a_6__11 a_6__10 a_6__9 a_6__8 a_6__7 a_6__6
+ a_6__5 a_6__4 a_6__3 a_6__2 a_6__1 a_6__0 a_5__15 a_5__14 a_5__13 a_5__12
+ a_5__11 a_5__10 a_5__9 a_5__8 a_5__7 a_5__6 a_5__5 a_5__4 a_5__3 a_5__2
+ a_5__1 a_5__0 a_4__15 a_4__14 a_4__13 a_4__12 a_4__11 a_4__10 a_4__9 a_4__8
+ a_4__7 a_4__6 a_4__5 a_4__4 a_4__3 a_4__2 a_4__1 a_4__0 a_3__15 a_3__14
+ a_3__13 a_3__12 a_3__11 a_3__10 a_3__9 a_3__8 a_3__7 a_3__6 a_3__5 a_3__4
+ a_3__3 a_3__2 a_3__1 a_3__0 a_2__15 a_2__14 a_2__13 a_2__12 a_2__11 a_2__10
+ a_2__9 a_2__8 a_2__7 a_2__6 a_2__5 a_2__4 a_2__3 a_2__2 a_2__1 a_2__0 a_1__15
+ a_1__14 a_1__13 a_1__12 a_1__11 a_1__10 a_1__9 a_1__8 a_1__7 a_1__6 a_1__5
+ a_1__4 a_1__3 a_1__2 a_1__1 a_1__0 a_0__15 a_0__14 a_0__13 a_0__12 a_0__11
+ a_0__10 a_0__9 a_0__8 a_0__7 a_0__6 a_0__5 a_0__4 a_0__3 a_0__2 a_0__1 a_0__0
+ f_9__15 f_9__14 f_9__13 f_9__12 f_9__11 f_9__10 f_9__9 f_9__8 f_9__7 f_9__6
+ f_9__5 f_9__4 f_9__3 f_9__2 f_9__1 f_9__0 f_8__15 f_8__14 f_8__13 f_8__12
+ f_8__11 f_8__10 f_8__9 f_8__8 f_8__7 f_8__6 f_8__5 f_8__4 f_8__3 f_8__2
+ f_8__1 f_8__0 f_7__15 f_7__14 f_7__13 f_7__12 f_7__11 f_7__10 f_7__9 f_7__8
+ f_7__7 f_7__6 f_7__5 f_7__4 f_7__3 f_7__2 f_7__1 f_7__0 f_6__15 f_6__14
+ f_6__13 f_6__12 f_6__11 f_6__10 f_6__9 f_6__8 f_6__7 f_6__6 f_6__5 f_6__4
+ f_6__3 f_6__2 f_6__1 f_6__0 f_5__15 f_5__14 f_5__13 f_5__12 f_5__11 f_5__10
+ f_5__9 f_5__8 f_5__7 f_5__6 f_5__5 f_5__4 f_5__3 f_5__2 f_5__1 f_5__0 f_4__15
+ f_4__14 f_4__13 f_4__12 f_4__11 f_4__10 f_4__9 f_4__8 f_4__7 f_4__6 f_4__5
+ f_4__4 f_4__3 f_4__2 f_4__1 f_4__0 f_3__15 f_3__14 f_3__13 f_3__12 f_3__11
+ f_3__10 f_3__9 f_3__8 f_3__7 f_3__6 f_3__5 f_3__4 f_3__3 f_3__2 f_3__1 f_3__0
+ f_2__15 f_2__14 f_2__13 f_2__12 f_2__11 f_2__10 f_2__9 f_2__8 f_2__7 f_2__6
+ f_2__5 f_2__4 f_2__3 f_2__2 f_2__1 f_2__0 f_1__15 f_1__14 f_1__13 f_1__12
+ f_1__11 f_1__10 f_1__9 f_1__8 f_1__7 f_1__6 f_1__5 f_1__4 f_1__3 f_1__2
+ f_1__1 f_1__0 f_0__15 f_0__14 f_0__13 f_0__12 f_0__11 f_0__10 f_0__9 f_0__8
+ f_0__7 f_0__6 f_0__5 f_0__4 f_0__3 f_0__2 f_0__1 f_0__0 save rst
Xgen_9_cmp1 NBitAdder_16 $PINS a[15]=a_9__15 a[14]=a_9__14 a[13]=a_9__13
+ a[12]=a_9__12 a[11]=a_9__11 a[10]=a_9__10 a[9]=a_9__9 a[8]=a_9__8 a[7]=a_9__7
+ a[6]=a_9__6 a[5]=a_9__5 a[4]=a_9__4 a[3]=a_9__3 a[2]=a_9__2 a[1]=a_9__1
+ a[0]=a_9__0 b[15]=outReg_9__15 b[14]=outReg_9__14 b[13]=outReg_9__13
+ b[12]=outReg_9__12 b[11]=outReg_9__11 b[10]=outReg_9__10 b[9]=outReg_9__9
+ b[8]=outReg_9__8 b[7]=outReg_9__7 b[6]=outReg_9__6 b[5]=outReg_9__5
+ b[4]=outReg_9__4 b[3]=outReg_9__3 b[2]=outReg_9__2 b[1]=outReg_9__1
+ b[0]=outReg_9__0 carryIn=GND sum[15]=f_9__15 sum[14]=f_9__14 sum[13]=f_9__13
+ sum[12]=f_9__12 sum[11]=f_9__11 sum[10]=f_9__10 sum[9]=f_9__9 sum[8]=f_9__8
+ sum[7]=f_9__7 sum[6]=f_9__6 sum[5]=f_9__5 sum[4]=f_9__4 sum[3]=f_9__3
+ sum[2]=f_9__2 sum[1]=f_9__1 sum[0]=f_9__0 carryOut=#dummy[0]
Xgen_9_cmp2 Reg_16 $PINS D[15]=f_9__15 D[14]=f_9__14 D[13]=f_9__13
+ D[12]=f_9__12 D[11]=f_9__11 D[10]=f_9__10 D[9]=f_9__9 D[8]=f_9__8 D[7]=f_9__7
+ D[6]=f_9__6 D[5]=f_9__5 D[4]=f_9__4 D[3]=f_9__3 D[2]=f_9__2 D[1]=f_9__1
+ D[0]=f_9__0 en=PWR clk=nx1131 rst=nx1139 Q[15]=outReg_9__15 Q[14]=outReg_9__14
+ Q[13]=outReg_9__13 Q[12]=outReg_9__12 Q[11]=outReg_9__11 Q[10]=outReg_9__10
+ Q[9]=outReg_9__9 Q[8]=outReg_9__8 Q[7]=outReg_9__7 Q[6]=outReg_9__6
+ Q[5]=outReg_9__5 Q[4]=outReg_9__4 Q[3]=outReg_9__3 Q[2]=outReg_9__2
+ Q[1]=outReg_9__1 Q[0]=outReg_9__0 Qbar[15]=#dummy[1] Qbar[14]=#dummy[2]
+ Qbar[13]=#dummy[3] Qbar[12]=#dummy[4] Qbar[11]=#dummy[5] Qbar[10]=#dummy[6]
+ Qbar[9]=#dummy[7] Qbar[8]=#dummy[8] Qbar[7]=#dummy[9] Qbar[6]=#dummy[10]
+ Qbar[5]=#dummy[11] Qbar[4]=#dummy[12] Qbar[3]=#dummy[13] Qbar[2]=#dummy[14]
+ Qbar[1]=#dummy[15] Qbar[0]=#dummy[16]
Xgen_8_cmp1 NBitAdder_16 $PINS a[15]=a_8__15 a[14]=a_8__14 a[13]=a_8__13
+ a[12]=a_8__12 a[11]=a_8__11 a[10]=a_8__10 a[9]=a_8__9 a[8]=a_8__8 a[7]=a_8__7
+ a[6]=a_8__6 a[5]=a_8__5 a[4]=a_8__4 a[3]=a_8__3 a[2]=a_8__2 a[1]=a_8__1
+ a[0]=a_8__0 b[15]=outReg_8__15 b[14]=outReg_8__14 b[13]=outReg_8__13
+ b[12]=outReg_8__12 b[11]=outReg_8__11 b[10]=outReg_8__10 b[9]=outReg_8__9
+ b[8]=outReg_8__8 b[7]=outReg_8__7 b[6]=outReg_8__6 b[5]=outReg_8__5
+ b[4]=outReg_8__4 b[3]=outReg_8__3 b[2]=outReg_8__2 b[1]=outReg_8__1
+ b[0]=outReg_8__0 carryIn=GND sum[15]=f_8__15 sum[14]=f_8__14 sum[13]=f_8__13
+ sum[12]=f_8__12 sum[11]=f_8__11 sum[10]=f_8__10 sum[9]=f_8__9 sum[8]=f_8__8
+ sum[7]=f_8__7 sum[6]=f_8__6 sum[5]=f_8__5 sum[4]=f_8__4 sum[3]=f_8__3
+ sum[2]=f_8__2 sum[1]=f_8__1 sum[0]=f_8__0 carryOut=#dummy[17]
Xgen_8_cmp2 Reg_16 $PINS D[15]=f_8__15 D[14]=f_8__14 D[13]=f_8__13
+ D[12]=f_8__12 D[11]=f_8__11 D[10]=f_8__10 D[9]=f_8__9 D[8]=f_8__8 D[7]=f_8__7
+ D[6]=f_8__6 D[5]=f_8__5 D[4]=f_8__4 D[3]=f_8__3 D[2]=f_8__2 D[1]=f_8__1
+ D[0]=f_8__0 en=PWR clk=nx1131 rst=nx1139 Q[15]=outReg_8__15 Q[14]=outReg_8__14
+ Q[13]=outReg_8__13 Q[12]=outReg_8__12 Q[11]=outReg_8__11 Q[10]=outReg_8__10
+ Q[9]=outReg_8__9 Q[8]=outReg_8__8 Q[7]=outReg_8__7 Q[6]=outReg_8__6
+ Q[5]=outReg_8__5 Q[4]=outReg_8__4 Q[3]=outReg_8__3 Q[2]=outReg_8__2
+ Q[1]=outReg_8__1 Q[0]=outReg_8__0 Qbar[15]=#dummy[18] Qbar[14]=#dummy[19]
+ Qbar[13]=#dummy[20] Qbar[12]=#dummy[21] Qbar[11]=#dummy[22] Qbar[10]=#dummy[23]
+ Qbar[9]=#dummy[24] Qbar[8]=#dummy[25] Qbar[7]=#dummy[26] Qbar[6]=#dummy[27]
+ Qbar[5]=#dummy[28] Qbar[4]=#dummy[29] Qbar[3]=#dummy[30] Qbar[2]=#dummy[31]
+ Qbar[1]=#dummy[32] Qbar[0]=#dummy[33]
Xgen_7_cmp1 NBitAdder_16 $PINS a[15]=a_7__15 a[14]=a_7__14 a[13]=a_7__13
+ a[12]=a_7__12 a[11]=a_7__11 a[10]=a_7__10 a[9]=a_7__9 a[8]=a_7__8 a[7]=a_7__7
+ a[6]=a_7__6 a[5]=a_7__5 a[4]=a_7__4 a[3]=a_7__3 a[2]=a_7__2 a[1]=a_7__1
+ a[0]=a_7__0 b[15]=outReg_7__15 b[14]=outReg_7__14 b[13]=outReg_7__13
+ b[12]=outReg_7__12 b[11]=outReg_7__11 b[10]=outReg_7__10 b[9]=outReg_7__9
+ b[8]=outReg_7__8 b[7]=outReg_7__7 b[6]=outReg_7__6 b[5]=outReg_7__5
+ b[4]=outReg_7__4 b[3]=outReg_7__3 b[2]=outReg_7__2 b[1]=outReg_7__1
+ b[0]=outReg_7__0 carryIn=GND sum[15]=f_7__15 sum[14]=f_7__14 sum[13]=f_7__13
+ sum[12]=f_7__12 sum[11]=f_7__11 sum[10]=f_7__10 sum[9]=f_7__9 sum[8]=f_7__8
+ sum[7]=f_7__7 sum[6]=f_7__6 sum[5]=f_7__5 sum[4]=f_7__4 sum[3]=f_7__3
+ sum[2]=f_7__2 sum[1]=f_7__1 sum[0]=f_7__0 carryOut=#dummy[34]
Xgen_7_cmp2 Reg_16 $PINS D[15]=f_7__15 D[14]=f_7__14 D[13]=f_7__13
+ D[12]=f_7__12 D[11]=f_7__11 D[10]=f_7__10 D[9]=f_7__9 D[8]=f_7__8 D[7]=f_7__7
+ D[6]=f_7__6 D[5]=f_7__5 D[4]=f_7__4 D[3]=f_7__3 D[2]=f_7__2 D[1]=f_7__1
+ D[0]=f_7__0 en=PWR clk=nx1131 rst=nx1139 Q[15]=outReg_7__15 Q[14]=outReg_7__14
+ Q[13]=outReg_7__13 Q[12]=outReg_7__12 Q[11]=outReg_7__11 Q[10]=outReg_7__10
+ Q[9]=outReg_7__9 Q[8]=outReg_7__8 Q[7]=outReg_7__7 Q[6]=outReg_7__6
+ Q[5]=outReg_7__5 Q[4]=outReg_7__4 Q[3]=outReg_7__3 Q[2]=outReg_7__2
+ Q[1]=outReg_7__1 Q[0]=outReg_7__0 Qbar[15]=#dummy[35] Qbar[14]=#dummy[36]
+ Qbar[13]=#dummy[37] Qbar[12]=#dummy[38] Qbar[11]=#dummy[39] Qbar[10]=#dummy[40]
+ Qbar[9]=#dummy[41] Qbar[8]=#dummy[42] Qbar[7]=#dummy[43] Qbar[6]=#dummy[44]
+ Qbar[5]=#dummy[45] Qbar[4]=#dummy[46] Qbar[3]=#dummy[47] Qbar[2]=#dummy[48]
+ Qbar[1]=#dummy[49] Qbar[0]=#dummy[50]
Xgen_6_cmp1 NBitAdder_16 $PINS a[15]=a_6__15 a[14]=a_6__14 a[13]=a_6__13
+ a[12]=a_6__12 a[11]=a_6__11 a[10]=a_6__10 a[9]=a_6__9 a[8]=a_6__8 a[7]=a_6__7
+ a[6]=a_6__6 a[5]=a_6__5 a[4]=a_6__4 a[3]=a_6__3 a[2]=a_6__2 a[1]=a_6__1
+ a[0]=a_6__0 b[15]=outReg_6__15 b[14]=outReg_6__14 b[13]=outReg_6__13
+ b[12]=outReg_6__12 b[11]=outReg_6__11 b[10]=outReg_6__10 b[9]=outReg_6__9
+ b[8]=outReg_6__8 b[7]=outReg_6__7 b[6]=outReg_6__6 b[5]=outReg_6__5
+ b[4]=outReg_6__4 b[3]=outReg_6__3 b[2]=outReg_6__2 b[1]=outReg_6__1
+ b[0]=outReg_6__0 carryIn=GND sum[15]=f_6__15 sum[14]=f_6__14 sum[13]=f_6__13
+ sum[12]=f_6__12 sum[11]=f_6__11 sum[10]=f_6__10 sum[9]=f_6__9 sum[8]=f_6__8
+ sum[7]=f_6__7 sum[6]=f_6__6 sum[5]=f_6__5 sum[4]=f_6__4 sum[3]=f_6__3
+ sum[2]=f_6__2 sum[1]=f_6__1 sum[0]=f_6__0 carryOut=#dummy[51]
Xgen_6_cmp2 Reg_16 $PINS D[15]=f_6__15 D[14]=f_6__14 D[13]=f_6__13
+ D[12]=f_6__12 D[11]=f_6__11 D[10]=f_6__10 D[9]=f_6__9 D[8]=f_6__8 D[7]=f_6__7
+ D[6]=f_6__6 D[5]=f_6__5 D[4]=f_6__4 D[3]=f_6__3 D[2]=f_6__2 D[1]=f_6__1
+ D[0]=f_6__0 en=PWR clk=nx1133 rst=nx1141 Q[15]=outReg_6__15 Q[14]=outReg_6__14
+ Q[13]=outReg_6__13 Q[12]=outReg_6__12 Q[11]=outReg_6__11 Q[10]=outReg_6__10
+ Q[9]=outReg_6__9 Q[8]=outReg_6__8 Q[7]=outReg_6__7 Q[6]=outReg_6__6
+ Q[5]=outReg_6__5 Q[4]=outReg_6__4 Q[3]=outReg_6__3 Q[2]=outReg_6__2
+ Q[1]=outReg_6__1 Q[0]=outReg_6__0 Qbar[15]=#dummy[52] Qbar[14]=#dummy[53]
+ Qbar[13]=#dummy[54] Qbar[12]=#dummy[55] Qbar[11]=#dummy[56] Qbar[10]=#dummy[57]
+ Qbar[9]=#dummy[58] Qbar[8]=#dummy[59] Qbar[7]=#dummy[60] Qbar[6]=#dummy[61]
+ Qbar[5]=#dummy[62] Qbar[4]=#dummy[63] Qbar[3]=#dummy[64] Qbar[2]=#dummy[65]
+ Qbar[1]=#dummy[66] Qbar[0]=#dummy[67]
Xgen_5_cmp1 NBitAdder_16 $PINS a[15]=a_5__15 a[14]=a_5__14 a[13]=a_5__13
+ a[12]=a_5__12 a[11]=a_5__11 a[10]=a_5__10 a[9]=a_5__9 a[8]=a_5__8 a[7]=a_5__7
+ a[6]=a_5__6 a[5]=a_5__5 a[4]=a_5__4 a[3]=a_5__3 a[2]=a_5__2 a[1]=a_5__1
+ a[0]=a_5__0 b[15]=outReg_5__15 b[14]=outReg_5__14 b[13]=outReg_5__13
+ b[12]=outReg_5__12 b[11]=outReg_5__11 b[10]=outReg_5__10 b[9]=outReg_5__9
+ b[8]=outReg_5__8 b[7]=outReg_5__7 b[6]=outReg_5__6 b[5]=outReg_5__5
+ b[4]=outReg_5__4 b[3]=outReg_5__3 b[2]=outReg_5__2 b[1]=outReg_5__1
+ b[0]=outReg_5__0 carryIn=GND sum[15]=f_5__15 sum[14]=f_5__14 sum[13]=f_5__13
+ sum[12]=f_5__12 sum[11]=f_5__11 sum[10]=f_5__10 sum[9]=f_5__9 sum[8]=f_5__8
+ sum[7]=f_5__7 sum[6]=f_5__6 sum[5]=f_5__5 sum[4]=f_5__4 sum[3]=f_5__3
+ sum[2]=f_5__2 sum[1]=f_5__1 sum[0]=f_5__0 carryOut=#dummy[68]
Xgen_5_cmp2 Reg_16 $PINS D[15]=f_5__15 D[14]=f_5__14 D[13]=f_5__13
+ D[12]=f_5__12 D[11]=f_5__11 D[10]=f_5__10 D[9]=f_5__9 D[8]=f_5__8 D[7]=f_5__7
+ D[6]=f_5__6 D[5]=f_5__5 D[4]=f_5__4 D[3]=f_5__3 D[2]=f_5__2 D[1]=f_5__1
+ D[0]=f_5__0 en=PWR clk=nx1133 rst=nx1141 Q[15]=outReg_5__15 Q[14]=outReg_5__14
+ Q[13]=outReg_5__13 Q[12]=outReg_5__12 Q[11]=outReg_5__11 Q[10]=outReg_5__10
+ Q[9]=outReg_5__9 Q[8]=outReg_5__8 Q[7]=outReg_5__7 Q[6]=outReg_5__6
+ Q[5]=outReg_5__5 Q[4]=outReg_5__4 Q[3]=outReg_5__3 Q[2]=outReg_5__2
+ Q[1]=outReg_5__1 Q[0]=outReg_5__0 Qbar[15]=#dummy[69] Qbar[14]=#dummy[70]
+ Qbar[13]=#dummy[71] Qbar[12]=#dummy[72] Qbar[11]=#dummy[73] Qbar[10]=#dummy[74]
+ Qbar[9]=#dummy[75] Qbar[8]=#dummy[76] Qbar[7]=#dummy[77] Qbar[6]=#dummy[78]
+ Qbar[5]=#dummy[79] Qbar[4]=#dummy[80] Qbar[3]=#dummy[81] Qbar[2]=#dummy[82]
+ Qbar[1]=#dummy[83] Qbar[0]=#dummy[84]
Xgen_4_cmp1 NBitAdder_16 $PINS a[15]=a_4__15 a[14]=a_4__14 a[13]=a_4__13
+ a[12]=a_4__12 a[11]=a_4__11 a[10]=a_4__10 a[9]=a_4__9 a[8]=a_4__8 a[7]=a_4__7
+ a[6]=a_4__6 a[5]=a_4__5 a[4]=a_4__4 a[3]=a_4__3 a[2]=a_4__2 a[1]=a_4__1
+ a[0]=a_4__0 b[15]=outReg_4__15 b[14]=outReg_4__14 b[13]=outReg_4__13
+ b[12]=outReg_4__12 b[11]=outReg_4__11 b[10]=outReg_4__10 b[9]=outReg_4__9
+ b[8]=outReg_4__8 b[7]=outReg_4__7 b[6]=outReg_4__6 b[5]=outReg_4__5
+ b[4]=outReg_4__4 b[3]=outReg_4__3 b[2]=outReg_4__2 b[1]=outReg_4__1
+ b[0]=outReg_4__0 carryIn=GND sum[15]=f_4__15 sum[14]=f_4__14 sum[13]=f_4__13
+ sum[12]=f_4__12 sum[11]=f_4__11 sum[10]=f_4__10 sum[9]=f_4__9 sum[8]=f_4__8
+ sum[7]=f_4__7 sum[6]=f_4__6 sum[5]=f_4__5 sum[4]=f_4__4 sum[3]=f_4__3
+ sum[2]=f_4__2 sum[1]=f_4__1 sum[0]=f_4__0 carryOut=#dummy[85]
Xgen_4_cmp2 Reg_16 $PINS D[15]=f_4__15 D[14]=f_4__14 D[13]=f_4__13
+ D[12]=f_4__12 D[11]=f_4__11 D[10]=f_4__10 D[9]=f_4__9 D[8]=f_4__8 D[7]=f_4__7
+ D[6]=f_4__6 D[5]=f_4__5 D[4]=f_4__4 D[3]=f_4__3 D[2]=f_4__2 D[1]=f_4__1
+ D[0]=f_4__0 en=PWR clk=nx1133 rst=nx1141 Q[15]=outReg_4__15 Q[14]=outReg_4__14
+ Q[13]=outReg_4__13 Q[12]=outReg_4__12 Q[11]=outReg_4__11 Q[10]=outReg_4__10
+ Q[9]=outReg_4__9 Q[8]=outReg_4__8 Q[7]=outReg_4__7 Q[6]=outReg_4__6
+ Q[5]=outReg_4__5 Q[4]=outReg_4__4 Q[3]=outReg_4__3 Q[2]=outReg_4__2
+ Q[1]=outReg_4__1 Q[0]=outReg_4__0 Qbar[15]=#dummy[86] Qbar[14]=#dummy[87]
+ Qbar[13]=#dummy[88] Qbar[12]=#dummy[89] Qbar[11]=#dummy[90] Qbar[10]=#dummy[91]
+ Qbar[9]=#dummy[92] Qbar[8]=#dummy[93] Qbar[7]=#dummy[94] Qbar[6]=#dummy[95]
+ Qbar[5]=#dummy[96] Qbar[4]=#dummy[97] Qbar[3]=#dummy[98] Qbar[2]=#dummy[99]
+ Qbar[1]=#dummy[100] Qbar[0]=#dummy[101]
Xgen_3_cmp1 NBitAdder_16 $PINS a[15]=a_3__15 a[14]=a_3__14 a[13]=a_3__13
+ a[12]=a_3__12 a[11]=a_3__11 a[10]=a_3__10 a[9]=a_3__9 a[8]=a_3__8 a[7]=a_3__7
+ a[6]=a_3__6 a[5]=a_3__5 a[4]=a_3__4 a[3]=a_3__3 a[2]=a_3__2 a[1]=a_3__1
+ a[0]=a_3__0 b[15]=outReg_3__15 b[14]=outReg_3__14 b[13]=outReg_3__13
+ b[12]=outReg_3__12 b[11]=outReg_3__11 b[10]=outReg_3__10 b[9]=outReg_3__9
+ b[8]=outReg_3__8 b[7]=outReg_3__7 b[6]=outReg_3__6 b[5]=outReg_3__5
+ b[4]=outReg_3__4 b[3]=outReg_3__3 b[2]=outReg_3__2 b[1]=outReg_3__1
+ b[0]=outReg_3__0 carryIn=GND sum[15]=f_3__15 sum[14]=f_3__14 sum[13]=f_3__13
+ sum[12]=f_3__12 sum[11]=f_3__11 sum[10]=f_3__10 sum[9]=f_3__9 sum[8]=f_3__8
+ sum[7]=f_3__7 sum[6]=f_3__6 sum[5]=f_3__5 sum[4]=f_3__4 sum[3]=f_3__3
+ sum[2]=f_3__2 sum[1]=f_3__1 sum[0]=f_3__0 carryOut=#dummy[102]
Xgen_3_cmp2 Reg_16 $PINS D[15]=f_3__15 D[14]=f_3__14 D[13]=f_3__13
+ D[12]=f_3__12 D[11]=f_3__11 D[10]=f_3__10 D[9]=f_3__9 D[8]=f_3__8 D[7]=f_3__7
+ D[6]=f_3__6 D[5]=f_3__5 D[4]=f_3__4 D[3]=f_3__3 D[2]=f_3__2 D[1]=f_3__1
+ D[0]=f_3__0 en=PWR clk=nx1135 rst=nx1143 Q[15]=outReg_3__15 Q[14]=outReg_3__14
+ Q[13]=outReg_3__13 Q[12]=outReg_3__12 Q[11]=outReg_3__11 Q[10]=outReg_3__10
+ Q[9]=outReg_3__9 Q[8]=outReg_3__8 Q[7]=outReg_3__7 Q[6]=outReg_3__6
+ Q[5]=outReg_3__5 Q[4]=outReg_3__4 Q[3]=outReg_3__3 Q[2]=outReg_3__2
+ Q[1]=outReg_3__1 Q[0]=outReg_3__0 Qbar[15]=#dummy[103] Qbar[14]=#dummy[104]
+ Qbar[13]=#dummy[105] Qbar[12]=#dummy[106] Qbar[11]=#dummy[107]
+ Qbar[10]=#dummy[108] Qbar[9]=#dummy[109] Qbar[8]=#dummy[110]
+ Qbar[7]=#dummy[111] Qbar[6]=#dummy[112] Qbar[5]=#dummy[113] Qbar[4]=#dummy[114]
+ Qbar[3]=#dummy[115] Qbar[2]=#dummy[116] Qbar[1]=#dummy[117] Qbar[0]=#dummy[118]
Xgen_2_cmp1 NBitAdder_16 $PINS a[15]=a_2__15 a[14]=a_2__14 a[13]=a_2__13
+ a[12]=a_2__12 a[11]=a_2__11 a[10]=a_2__10 a[9]=a_2__9 a[8]=a_2__8 a[7]=a_2__7
+ a[6]=a_2__6 a[5]=a_2__5 a[4]=a_2__4 a[3]=a_2__3 a[2]=a_2__2 a[1]=a_2__1
+ a[0]=a_2__0 b[15]=outReg_2__15 b[14]=outReg_2__14 b[13]=outReg_2__13
+ b[12]=outReg_2__12 b[11]=outReg_2__11 b[10]=outReg_2__10 b[9]=outReg_2__9
+ b[8]=outReg_2__8 b[7]=outReg_2__7 b[6]=outReg_2__6 b[5]=outReg_2__5
+ b[4]=outReg_2__4 b[3]=outReg_2__3 b[2]=outReg_2__2 b[1]=outReg_2__1
+ b[0]=outReg_2__0 carryIn=GND sum[15]=f_2__15 sum[14]=f_2__14 sum[13]=f_2__13
+ sum[12]=f_2__12 sum[11]=f_2__11 sum[10]=f_2__10 sum[9]=f_2__9 sum[8]=f_2__8
+ sum[7]=f_2__7 sum[6]=f_2__6 sum[5]=f_2__5 sum[4]=f_2__4 sum[3]=f_2__3
+ sum[2]=f_2__2 sum[1]=f_2__1 sum[0]=f_2__0 carryOut=#dummy[119]
Xgen_2_cmp2 Reg_16 $PINS D[15]=f_2__15 D[14]=f_2__14 D[13]=f_2__13
+ D[12]=f_2__12 D[11]=f_2__11 D[10]=f_2__10 D[9]=f_2__9 D[8]=f_2__8 D[7]=f_2__7
+ D[6]=f_2__6 D[5]=f_2__5 D[4]=f_2__4 D[3]=f_2__3 D[2]=f_2__2 D[1]=f_2__1
+ D[0]=f_2__0 en=PWR clk=nx949 rst=nx953 Q[15]=outReg_2__15 Q[14]=outReg_2__14
+ Q[13]=outReg_2__13 Q[12]=outReg_2__12 Q[11]=outReg_2__11 Q[10]=outReg_2__10
+ Q[9]=outReg_2__9 Q[8]=outReg_2__8 Q[7]=outReg_2__7 Q[6]=outReg_2__6
+ Q[5]=outReg_2__5 Q[4]=outReg_2__4 Q[3]=outReg_2__3 Q[2]=outReg_2__2
+ Q[1]=outReg_2__1 Q[0]=outReg_2__0 Qbar[15]=#dummy[120] Qbar[14]=#dummy[121]
+ Qbar[13]=#dummy[122] Qbar[12]=#dummy[123] Qbar[11]=#dummy[124]
+ Qbar[10]=#dummy[125] Qbar[9]=#dummy[126] Qbar[8]=#dummy[127]
+ Qbar[7]=#dummy[128] Qbar[6]=#dummy[129] Qbar[5]=#dummy[130] Qbar[4]=#dummy[131]
+ Qbar[3]=#dummy[132] Qbar[2]=#dummy[133] Qbar[1]=#dummy[134] Qbar[0]=#dummy[135]
Xgen_1_cmp1 NBitAdder_16 $PINS a[15]=a_1__15 a[14]=a_1__14 a[13]=a_1__13
+ a[12]=a_1__12 a[11]=a_1__11 a[10]=a_1__10 a[9]=a_1__9 a[8]=a_1__8 a[7]=a_1__7
+ a[6]=a_1__6 a[5]=a_1__5 a[4]=a_1__4 a[3]=a_1__3 a[2]=a_1__2 a[1]=a_1__1
+ a[0]=a_1__0 b[15]=outReg_1__15 b[14]=outReg_1__14 b[13]=outReg_1__13
+ b[12]=outReg_1__12 b[11]=outReg_1__11 b[10]=outReg_1__10 b[9]=outReg_1__9
+ b[8]=outReg_1__8 b[7]=outReg_1__7 b[6]=outReg_1__6 b[5]=outReg_1__5
+ b[4]=outReg_1__4 b[3]=outReg_1__3 b[2]=outReg_1__2 b[1]=outReg_1__1
+ b[0]=outReg_1__0 carryIn=GND sum[15]=f_1__15 sum[14]=f_1__14 sum[13]=f_1__13
+ sum[12]=f_1__12 sum[11]=f_1__11 sum[10]=f_1__10 sum[9]=f_1__9 sum[8]=f_1__8
+ sum[7]=f_1__7 sum[6]=f_1__6 sum[5]=f_1__5 sum[4]=f_1__4 sum[3]=f_1__3
+ sum[2]=f_1__2 sum[1]=f_1__1 sum[0]=f_1__0 carryOut=#dummy[136]
Xgen_1_cmp2 Reg_16 $PINS D[15]=f_1__15 D[14]=f_1__14 D[13]=f_1__13
+ D[12]=f_1__12 D[11]=f_1__11 D[10]=f_1__10 D[9]=f_1__9 D[8]=f_1__8 D[7]=f_1__7
+ D[6]=f_1__6 D[5]=f_1__5 D[4]=f_1__4 D[3]=f_1__3 D[2]=f_1__2 D[1]=f_1__1
+ D[0]=f_1__0 en=PWR clk=nx949 rst=nx953 Q[15]=outReg_1__15 Q[14]=outReg_1__14
+ Q[13]=outReg_1__13 Q[12]=outReg_1__12 Q[11]=outReg_1__11 Q[10]=outReg_1__10
+ Q[9]=outReg_1__9 Q[8]=outReg_1__8 Q[7]=outReg_1__7 Q[6]=outReg_1__6
+ Q[5]=outReg_1__5 Q[4]=outReg_1__4 Q[3]=outReg_1__3 Q[2]=outReg_1__2
+ Q[1]=outReg_1__1 Q[0]=outReg_1__0 Qbar[15]=#dummy[137] Qbar[14]=#dummy[138]
+ Qbar[13]=#dummy[139] Qbar[12]=#dummy[140] Qbar[11]=#dummy[141]
+ Qbar[10]=#dummy[142] Qbar[9]=#dummy[143] Qbar[8]=#dummy[144]
+ Qbar[7]=#dummy[145] Qbar[6]=#dummy[146] Qbar[5]=#dummy[147] Qbar[4]=#dummy[148]
+ Qbar[3]=#dummy[149] Qbar[2]=#dummy[150] Qbar[1]=#dummy[151] Qbar[0]=#dummy[152]
Xgen_0_cmp1 NBitAdder_16 $PINS a[15]=a_0__15 a[14]=a_0__14 a[13]=a_0__13
+ a[12]=a_0__12 a[11]=a_0__11 a[10]=a_0__10 a[9]=a_0__9 a[8]=a_0__8 a[7]=a_0__7
+ a[6]=a_0__6 a[5]=a_0__5 a[4]=a_0__4 a[3]=a_0__3 a[2]=a_0__2 a[1]=a_0__1
+ a[0]=a_0__0 b[15]=outReg_0__15 b[14]=outReg_0__14 b[13]=outReg_0__13
+ b[12]=outReg_0__12 b[11]=outReg_0__11 b[10]=outReg_0__10 b[9]=outReg_0__9
+ b[8]=outReg_0__8 b[7]=outReg_0__7 b[6]=outReg_0__6 b[5]=outReg_0__5
+ b[4]=outReg_0__4 b[3]=outReg_0__3 b[2]=outReg_0__2 b[1]=outReg_0__1
+ b[0]=outReg_0__0 carryIn=GND sum[15]=f_0__15 sum[14]=f_0__14 sum[13]=f_0__13
+ sum[12]=f_0__12 sum[11]=f_0__11 sum[10]=f_0__10 sum[9]=f_0__9 sum[8]=f_0__8
+ sum[7]=f_0__7 sum[6]=f_0__6 sum[5]=f_0__5 sum[4]=f_0__4 sum[3]=f_0__3
+ sum[2]=f_0__2 sum[1]=f_0__1 sum[0]=f_0__0 carryOut=#dummy[153]
Xgen_0_cmp2 Reg_16 $PINS D[15]=f_0__15 D[14]=f_0__14 D[13]=f_0__13
+ D[12]=f_0__12 D[11]=f_0__11 D[10]=f_0__10 D[9]=f_0__9 D[8]=f_0__8 D[7]=f_0__7
+ D[6]=f_0__6 D[5]=f_0__5 D[4]=f_0__4 D[3]=f_0__3 D[2]=f_0__2 D[1]=f_0__1
+ D[0]=f_0__0 en=PWR clk=nx949 rst=nx953 Q[15]=outReg_0__15 Q[14]=outReg_0__14
+ Q[13]=outReg_0__13 Q[12]=outReg_0__12 Q[11]=outReg_0__11 Q[10]=outReg_0__10
+ Q[9]=outReg_0__9 Q[8]=outReg_0__8 Q[7]=outReg_0__7 Q[6]=outReg_0__6
+ Q[5]=outReg_0__5 Q[4]=outReg_0__4 Q[3]=outReg_0__3 Q[2]=outReg_0__2
+ Q[1]=outReg_0__1 Q[0]=outReg_0__0 Qbar[15]=#dummy[154] Qbar[14]=#dummy[155]
+ Qbar[13]=#dummy[156] Qbar[12]=#dummy[157] Qbar[11]=#dummy[158]
+ Qbar[10]=#dummy[159] Qbar[9]=#dummy[160] Qbar[8]=#dummy[161]
+ Qbar[7]=#dummy[162] Qbar[6]=#dummy[163] Qbar[5]=#dummy[164] Qbar[4]=#dummy[165]
+ Qbar[3]=#dummy[166] Qbar[2]=#dummy[167] Qbar[1]=#dummy[168] Qbar[0]=#dummy[169]
Xix946 buf02 $PINS Y=nx947 A=save
Xix948 buf02 $PINS Y=nx949 A=save
Xix950 buf02 $PINS Y=nx951 A=rst
Xix952 buf02 $PINS Y=nx953 A=rst
Xix1128 inv01 $PINS Y=nx1129 A=nx947
Xix1130 inv01 $PINS Y=nx1131 A=nx1129
Xix1132 inv01 $PINS Y=nx1133 A=nx1129
Xix1134 inv01 $PINS Y=nx1135 A=nx1129
Xix1136 inv01 $PINS Y=nx1137 A=nx951
Xix1138 inv01 $PINS Y=nx1139 A=nx1137
Xix1140 inv01 $PINS Y=nx1141 A=nx1137
Xix1142 inv01 $PINS Y=nx1143 A=nx1137
.ENDS

.SUBCKT nMul8x16_10 q_9__7 q_9__6 q_9__5 q_9__4 q_9__3 q_9__2 q_9__1 q_9__0
+ q_8__7 q_8__6 q_8__5 q_8__4 q_8__3 q_8__2 q_8__1 q_8__0 q_7__7 q_7__6 q_7__5
+ q_7__4 q_7__3 q_7__2 q_7__1 q_7__0 q_6__7 q_6__6 q_6__5 q_6__4 q_6__3 q_6__2
+ q_6__1 q_6__0 q_5__7 q_5__6 q_5__5 q_5__4 q_5__3 q_5__2 q_5__1 q_5__0 q_4__7
+ q_4__6 q_4__5 q_4__4 q_4__3 q_4__2 q_4__1 q_4__0 q_3__7 q_3__6 q_3__5 q_3__4
+ q_3__3 q_3__2 q_3__1 q_3__0 q_2__7 q_2__6 q_2__5 q_2__4 q_2__3 q_2__2 q_2__1
+ q_2__0 q_1__7 q_1__6 q_1__5 q_1__4 q_1__3 q_1__2 q_1__1 q_1__0 q_0__7 q_0__6
+ q_0__5 q_0__4 q_0__3 q_0__2 q_0__1 q_0__0 m_9__15 m_9__14 m_9__13 m_9__12
+ m_9__11 m_9__10 m_9__9 m_9__8 m_9__7 m_9__6 m_9__5 m_9__4 m_9__3 m_9__2
+ m_9__1 m_9__0 m_8__15 m_8__14 m_8__13 m_8__12 m_8__11 m_8__10 m_8__9 m_8__8
+ m_8__7 m_8__6 m_8__5 m_8__4 m_8__3 m_8__2 m_8__1 m_8__0 m_7__15 m_7__14
+ m_7__13 m_7__12 m_7__11 m_7__10 m_7__9 m_7__8 m_7__7 m_7__6 m_7__5 m_7__4
+ m_7__3 m_7__2 m_7__1 m_7__0 m_6__15 m_6__14 m_6__13 m_6__12 m_6__11 m_6__10
+ m_6__9 m_6__8 m_6__7 m_6__6 m_6__5 m_6__4 m_6__3 m_6__2 m_6__1 m_6__0 m_5__15
+ m_5__14 m_5__13 m_5__12 m_5__11 m_5__10 m_5__9 m_5__8 m_5__7 m_5__6 m_5__5
+ m_5__4 m_5__3 m_5__2 m_5__1 m_5__0 m_4__15 m_4__14 m_4__13 m_4__12 m_4__11
+ m_4__10 m_4__9 m_4__8 m_4__7 m_4__6 m_4__5 m_4__4 m_4__3 m_4__2 m_4__1 m_4__0
+ m_3__15 m_3__14 m_3__13 m_3__12 m_3__11 m_3__10 m_3__9 m_3__8 m_3__7 m_3__6
+ m_3__5 m_3__4 m_3__3 m_3__2 m_3__1 m_3__0 m_2__15 m_2__14 m_2__13 m_2__12
+ m_2__11 m_2__10 m_2__9 m_2__8 m_2__7 m_2__6 m_2__5 m_2__4 m_2__3 m_2__2
+ m_2__1 m_2__0 m_1__15 m_1__14 m_1__13 m_1__12 m_1__11 m_1__10 m_1__9 m_1__8
+ m_1__7 m_1__6 m_1__5 m_1__4 m_1__3 m_1__2 m_1__1 m_1__0 m_0__15 m_0__14
+ m_0__13 m_0__12 m_0__11 m_0__10 m_0__9 m_0__8 m_0__7 m_0__6 m_0__5 m_0__4
+ m_0__3 m_0__2 m_0__1 m_0__0 f_9__15 f_9__14 f_9__13 f_9__12 f_9__11 f_9__10
+ f_9__9 f_9__8 f_9__7 f_9__6 f_9__5 f_9__4 f_9__3 f_9__2 f_9__1 f_9__0 f_8__15
+ f_8__14 f_8__13 f_8__12 f_8__11 f_8__10 f_8__9 f_8__8 f_8__7 f_8__6 f_8__5
+ f_8__4 f_8__3 f_8__2 f_8__1 f_8__0 f_7__15 f_7__14 f_7__13 f_7__12 f_7__11
+ f_7__10 f_7__9 f_7__8 f_7__7 f_7__6 f_7__5 f_7__4 f_7__3 f_7__2 f_7__1 f_7__0
+ f_6__15 f_6__14 f_6__13 f_6__12 f_6__11 f_6__10 f_6__9 f_6__8 f_6__7 f_6__6
+ f_6__5 f_6__4 f_6__3 f_6__2 f_6__1 f_6__0 f_5__15 f_5__14 f_5__13 f_5__12
+ f_5__11 f_5__10 f_5__9 f_5__8 f_5__7 f_5__6 f_5__5 f_5__4 f_5__3 f_5__2
+ f_5__1 f_5__0 f_4__15 f_4__14 f_4__13 f_4__12 f_4__11 f_4__10 f_4__9 f_4__8
+ f_4__7 f_4__6 f_4__5 f_4__4 f_4__3 f_4__2 f_4__1 f_4__0 f_3__15 f_3__14
+ f_3__13 f_3__12 f_3__11 f_3__10 f_3__9 f_3__8 f_3__7 f_3__6 f_3__5 f_3__4
+ f_3__3 f_3__2 f_3__1 f_3__0 f_2__15 f_2__14 f_2__13 f_2__12 f_2__11 f_2__10
+ f_2__9 f_2__8 f_2__7 f_2__6 f_2__5 f_2__4 f_2__3 f_2__2 f_2__1 f_2__0 f_1__15
+ f_1__14 f_1__13 f_1__12 f_1__11 f_1__10 f_1__9 f_1__8 f_1__7 f_1__6 f_1__5
+ f_1__4 f_1__3 f_1__2 f_1__1 f_1__0 f_0__15 f_0__14 f_0__13 f_0__12 f_0__11
+ f_0__10 f_0__9 f_0__8 f_0__7 f_0__6 f_0__5 f_0__4 f_0__3 f_0__2 f_0__1 f_0__0
+ clk start rst done working
Xgen_9_cmp Mul8x16 $PINS q[7]=q_9__7 q[6]=q_9__6 q[5]=q_9__5 q[4]=q_9__4
+ q[3]=q_9__3 q[2]=q_9__2 q[1]=q_9__1 q[0]=q_9__0 m[15]=m_9__15 m[14]=m_9__14
+ m[13]=m_9__13 m[12]=m_9__12 m[11]=m_9__11 m[10]=m_9__10 m[9]=m_9__9 m[8]=m_9__8
+ m[7]=m_9__7 m[6]=m_9__6 m[5]=m_9__5 m[4]=m_9__4 m[3]=m_9__3 m[2]=m_9__2
+ m[1]=m_9__1 m[0]=m_9__0 fMul[15]=f_9__15 fMul[14]=f_9__14 fMul[13]=f_9__13
+ fMul[12]=f_9__12 fMul[11]=f_9__11 fMul[10]=f_9__10 fMul[9]=f_9__9
+ fMul[8]=f_9__8 fMul[7]=f_9__7 fMul[6]=f_9__6 fMul[5]=f_9__5 fMul[4]=f_9__4
+ fMul[3]=f_9__3 fMul[2]=f_9__2 fMul[1]=f_9__1 fMul[0]=f_9__0 clk=nx414
+ start=nx445 rst=nx418 sel=nx368 startAndPause=nx451
Xgen_8_cmp Mul8x16 $PINS q[7]=q_8__7 q[6]=q_8__6 q[5]=q_8__5 q[4]=q_8__4
+ q[3]=q_8__3 q[2]=q_8__2 q[1]=q_8__1 q[0]=q_8__0 m[15]=m_8__15 m[14]=m_8__14
+ m[13]=m_8__13 m[12]=m_8__12 m[11]=m_8__11 m[10]=m_8__10 m[9]=m_8__9 m[8]=m_8__8
+ m[7]=m_8__7 m[6]=m_8__6 m[5]=m_8__5 m[4]=m_8__4 m[3]=m_8__3 m[2]=m_8__2
+ m[1]=m_8__1 m[0]=m_8__0 fMul[15]=f_8__15 fMul[14]=f_8__14 fMul[13]=f_8__13
+ fMul[12]=f_8__12 fMul[11]=f_8__11 fMul[10]=f_8__10 fMul[9]=f_8__9
+ fMul[8]=f_8__8 fMul[7]=f_8__7 fMul[6]=f_8__6 fMul[5]=f_8__5 fMul[4]=f_8__4
+ fMul[3]=f_8__3 fMul[2]=f_8__2 fMul[1]=f_8__1 fMul[0]=f_8__0 clk=nx414
+ start=nx445 rst=nx382 sel=nx368 startAndPause=nx453
Xgen_7_cmp Mul8x16 $PINS q[7]=q_7__7 q[6]=q_7__6 q[5]=q_7__5 q[4]=q_7__4
+ q[3]=q_7__3 q[2]=q_7__2 q[1]=q_7__1 q[0]=q_7__0 m[15]=m_7__15 m[14]=m_7__14
+ m[13]=m_7__13 m[12]=m_7__12 m[11]=m_7__11 m[10]=m_7__10 m[9]=m_7__9 m[8]=m_7__8
+ m[7]=m_7__7 m[6]=m_7__6 m[5]=m_7__5 m[4]=m_7__4 m[3]=m_7__3 m[2]=m_7__2
+ m[1]=m_7__1 m[0]=m_7__0 fMul[15]=f_7__15 fMul[14]=f_7__14 fMul[13]=f_7__13
+ fMul[12]=f_7__12 fMul[11]=f_7__11 fMul[10]=f_7__10 fMul[9]=f_7__9
+ fMul[8]=f_7__8 fMul[7]=f_7__7 fMul[6]=f_7__6 fMul[5]=f_7__5 fMul[4]=f_7__4
+ fMul[3]=f_7__3 fMul[2]=f_7__2 fMul[1]=f_7__1 fMul[0]=f_7__0 clk=nx414
+ start=nx396 rst=nx420 sel=nx368 startAndPause=nx406
Xgen_6_cmp Mul8x16 $PINS q[7]=q_6__7 q[6]=q_6__6 q[5]=q_6__5 q[4]=q_6__4
+ q[3]=q_6__3 q[2]=q_6__2 q[1]=q_6__1 q[0]=q_6__0 m[15]=m_6__15 m[14]=m_6__14
+ m[13]=m_6__13 m[12]=m_6__12 m[11]=m_6__11 m[10]=m_6__10 m[9]=m_6__9 m[8]=m_6__8
+ m[7]=m_6__7 m[6]=m_6__6 m[5]=m_6__5 m[4]=m_6__4 m[3]=m_6__3 m[2]=m_6__2
+ m[1]=m_6__1 m[0]=m_6__0 fMul[15]=f_6__15 fMul[14]=f_6__14 fMul[13]=f_6__13
+ fMul[12]=f_6__12 fMul[11]=f_6__11 fMul[10]=f_6__10 fMul[9]=f_6__9
+ fMul[8]=f_6__8 fMul[7]=f_6__7 fMul[6]=f_6__6 fMul[5]=f_6__5 fMul[4]=f_6__4
+ fMul[3]=f_6__3 fMul[2]=f_6__2 fMul[1]=f_6__1 fMul[0]=f_6__0 clk=nx416
+ start=nx447 rst=nx384 sel=nx368 startAndPause=nx455
Xgen_5_cmp Mul8x16 $PINS q[7]=q_5__7 q[6]=q_5__6 q[5]=q_5__5 q[4]=q_5__4
+ q[3]=q_5__3 q[2]=q_5__2 q[1]=q_5__1 q[0]=q_5__0 m[15]=m_5__15 m[14]=m_5__14
+ m[13]=m_5__13 m[12]=m_5__12 m[11]=m_5__11 m[10]=m_5__10 m[9]=m_5__9 m[8]=m_5__8
+ m[7]=m_5__7 m[6]=m_5__6 m[5]=m_5__5 m[4]=m_5__4 m[3]=m_5__3 m[2]=m_5__2
+ m[1]=m_5__1 m[0]=m_5__0 fMul[15]=f_5__15 fMul[14]=f_5__14 fMul[13]=f_5__13
+ fMul[12]=f_5__12 fMul[11]=f_5__11 fMul[10]=f_5__10 fMul[9]=f_5__9
+ fMul[8]=f_5__8 fMul[7]=f_5__7 fMul[6]=f_5__6 fMul[5]=f_5__5 fMul[4]=f_5__4
+ fMul[3]=f_5__3 fMul[2]=f_5__2 fMul[1]=f_5__1 fMul[0]=f_5__0 clk=nx416
+ start=nx447 rst=nx433 sel=nx368 startAndPause=nx457
Xgen_4_cmp Mul8x16 $PINS q[7]=q_4__7 q[6]=q_4__6 q[5]=q_4__5 q[4]=q_4__4
+ q[3]=q_4__3 q[2]=q_4__2 q[1]=q_4__1 q[0]=q_4__0 m[15]=m_4__15 m[14]=m_4__14
+ m[13]=m_4__13 m[12]=m_4__12 m[11]=m_4__11 m[10]=m_4__10 m[9]=m_4__9 m[8]=m_4__8
+ m[7]=m_4__7 m[6]=m_4__6 m[5]=m_4__5 m[4]=m_4__4 m[3]=m_4__3 m[2]=m_4__2
+ m[1]=m_4__1 m[0]=m_4__0 fMul[15]=f_4__15 fMul[14]=f_4__14 fMul[13]=f_4__13
+ fMul[12]=f_4__12 fMul[11]=f_4__11 fMul[10]=f_4__10 fMul[9]=f_4__9
+ fMul[8]=f_4__8 fMul[7]=f_4__7 fMul[6]=f_4__6 fMul[5]=f_4__5 fMul[4]=f_4__4
+ fMul[3]=f_4__3 fMul[2]=f_4__2 fMul[1]=f_4__1 fMul[0]=f_4__0 clk=nx416
+ start=nx398 rst=nx435 sel=nx368 startAndPause=nx408
Xgen_3_cmp Mul8x16 $PINS q[7]=q_3__7 q[6]=q_3__6 q[5]=q_3__5 q[4]=q_3__4
+ q[3]=q_3__3 q[2]=q_3__2 q[1]=q_3__1 q[0]=q_3__0 m[15]=m_3__15 m[14]=m_3__14
+ m[13]=m_3__13 m[12]=m_3__12 m[11]=m_3__11 m[10]=m_3__10 m[9]=m_3__9 m[8]=m_3__8
+ m[7]=m_3__7 m[6]=m_3__6 m[5]=m_3__5 m[4]=m_3__4 m[3]=m_3__3 m[2]=m_3__2
+ m[1]=m_3__1 m[0]=m_3__0 fMul[15]=f_3__15 fMul[14]=f_3__14 fMul[13]=f_3__13
+ fMul[12]=f_3__12 fMul[11]=f_3__11 fMul[10]=f_3__10 fMul[9]=f_3__9
+ fMul[8]=f_3__8 fMul[7]=f_3__7 fMul[6]=f_3__6 fMul[5]=f_3__5 fMul[4]=f_3__4
+ fMul[3]=f_3__3 fMul[2]=f_3__2 fMul[1]=f_3__1 fMul[0]=f_3__0 clk=nx372
+ start=nx449 rst=nx437 sel=nx368 startAndPause=nx410
Xgen_2_cmp Mul8x16 $PINS q[7]=q_2__7 q[6]=q_2__6 q[5]=q_2__5 q[4]=q_2__4
+ q[3]=q_2__3 q[2]=q_2__2 q[1]=q_2__1 q[0]=q_2__0 m[15]=m_2__15 m[14]=m_2__14
+ m[13]=m_2__13 m[12]=m_2__12 m[11]=m_2__11 m[10]=m_2__10 m[9]=m_2__9 m[8]=m_2__8
+ m[7]=m_2__7 m[6]=m_2__6 m[5]=m_2__5 m[4]=m_2__4 m[3]=m_2__3 m[2]=m_2__2
+ m[1]=m_2__1 m[0]=m_2__0 fMul[15]=f_2__15 fMul[14]=f_2__14 fMul[13]=f_2__13
+ fMul[12]=f_2__12 fMul[11]=f_2__11 fMul[10]=f_2__10 fMul[9]=f_2__9
+ fMul[8]=f_2__8 fMul[7]=f_2__7 fMul[6]=f_2__6 fMul[5]=f_2__5 fMul[4]=f_2__4
+ fMul[3]=f_2__3 fMul[2]=f_2__2 fMul[1]=f_2__1 fMul[0]=f_2__0 clk=nx374
+ start=nx449 rst=nx439 sel=nx370 startAndPause=nx461
Xgen_1_cmp Mul8x16 $PINS q[7]=q_1__7 q[6]=q_1__6 q[5]=q_1__5 q[4]=q_1__4
+ q[3]=q_1__3 q[2]=q_1__2 q[1]=q_1__1 q[0]=q_1__0 m[15]=m_1__15 m[14]=m_1__14
+ m[13]=m_1__13 m[12]=m_1__12 m[11]=m_1__11 m[10]=m_1__10 m[9]=m_1__9 m[8]=m_1__8
+ m[7]=m_1__7 m[6]=m_1__6 m[5]=m_1__5 m[4]=m_1__4 m[3]=m_1__3 m[2]=m_1__2
+ m[1]=m_1__1 m[0]=m_1__0 fMul[15]=f_1__15 fMul[14]=f_1__14 fMul[13]=f_1__13
+ fMul[12]=f_1__12 fMul[11]=f_1__11 fMul[10]=f_1__10 fMul[9]=f_1__9
+ fMul[8]=f_1__8 fMul[7]=f_1__7 fMul[6]=f_1__6 fMul[5]=f_1__5 fMul[4]=f_1__4
+ fMul[3]=f_1__3 fMul[2]=f_1__2 fMul[1]=f_1__1 fMul[0]=f_1__0 clk=nx374
+ start=nx400 rst=nx441 sel=nx370 startAndPause=nx463
Xgen_0_cmp Mul8x16 $PINS q[7]=q_0__7 q[6]=q_0__6 q[5]=q_0__5 q[4]=q_0__4
+ q[3]=q_0__3 q[2]=q_0__2 q[1]=q_0__1 q[0]=q_0__0 m[15]=m_0__15 m[14]=m_0__14
+ m[13]=m_0__13 m[12]=m_0__12 m[11]=m_0__11 m[10]=m_0__10 m[9]=m_0__9 m[8]=m_0__8
+ m[7]=m_0__7 m[6]=m_0__6 m[5]=m_0__5 m[4]=m_0__4 m[3]=m_0__3 m[2]=m_0__2
+ m[1]=m_0__1 m[0]=m_0__0 fMul[15]=f_0__15 fMul[14]=f_0__14 fMul[13]=f_0__13
+ fMul[12]=f_0__12 fMul[11]=f_0__11 fMul[10]=f_0__10 fMul[9]=f_0__9
+ fMul[8]=f_0__8 fMul[7]=f_0__7 fMul[6]=f_0__6 fMul[5]=f_0__5 fMul[4]=f_0__4
+ fMul[3]=f_0__3 fMul[2]=f_0__2 fMul[1]=f_0__1 fMul[0]=f_0__0 clk=nx374
+ start=nx402 rst=nx443 sel=nx370 startAndPause=nx465
XStartCaptuerCmp RisingHolderHalfCycle $PINS transition=nx445 clk=clk rst=nx418
+ f=restartDetection
XCounterCmp ShiftReg_3 $PINS outp[3]=done outp[2]=#dummy[0] outp[1]=#dummy[1]
+ outp[0]=counter_0 clk=clk en=nx366 rst=counterRst
XfirtStartLachCmp Reg_1 $PINS D[0]=PWR en=PWR clk=nx402 rst=nx392
+ Q[0]=firstStart Qbar[0]=#dummy[2]
Xix3 or02 $PINS Y=counterRst A0=nx420 A1=restartDetection
Xix7 nor02ii $PINS Y=working A0=done A1=firstStart
Xix363 buf02 $PINS Y=nx364 A=working
Xix365 buf02 $PINS Y=nx366 A=working
Xix367 buf02 $PINS Y=nx368 A=counter_0
Xix369 buf02 $PINS Y=nx370 A=counter_0
Xix371 inv01 $PINS Y=nx372 A=clk
Xix373 inv01 $PINS Y=nx374 A=clk
Xix381 inv01 $PINS Y=nx382 A=nx380
Xix383 inv01 $PINS Y=nx384 A=nx380
Xix391 inv01 $PINS Y=nx392 A=nx380
Xix395 inv02 $PINS Y=nx396 A=nx394_XX0_XREP41
Xix397 inv02 $PINS Y=nx398 A=nx394_XX0_XREP41
Xix399 inv02 $PINS Y=nx400 A=nx394
Xix401 inv02 $PINS Y=nx402 A=nx394
Xix403 inv01 $PINS Y=nx404 A=nx364
Xix405 inv01 $PINS Y=nx406 A=nx404
Xix407 inv01 $PINS Y=nx408 A=nx404
Xix409 inv01 $PINS Y=nx410 A=nx404
Xix411 buf02 $PINS Y=nx412 A=working
Xix413 inv01 $PINS Y=nx414 A=clk
Xix415 inv01 $PINS Y=nx416 A=clk
Xix417 inv01 $PINS Y=nx418 A=nx380
Xix419 inv01 $PINS Y=nx420 A=nx467
Xix393 inv01 $PINS Y=nx394 A=start
Xix393_0_XREP41 inv01 $PINS Y=nx394_XX0_XREP41 A=start
Xix379 inv01 $PINS Y=nx380 A=rst
Xix379_0_XREP43 inv01 $PINS Y=nx380_XX0_XREP43 A=rst
Xix432 inv01 $PINS Y=nx433 A=nx467
Xix434 inv01 $PINS Y=nx435 A=nx467
Xix436 inv01 $PINS Y=nx437 A=nx467
Xix438 inv01 $PINS Y=nx439 A=nx380_XX0_XREP43
Xix440 inv01 $PINS Y=nx441 A=nx380_XX0_XREP43
Xix442 inv01 $PINS Y=nx443 A=nx380_XX0_XREP43
Xix444 inv02 $PINS Y=nx445 A=nx394_XX0_XREP41
Xix446 inv02 $PINS Y=nx447 A=nx394_XX0_XREP41
Xix448 inv02 $PINS Y=nx449 A=nx394
Xix450 inv01 $PINS Y=nx451 A=nx404
Xix452 inv01 $PINS Y=nx453 A=nx404
Xix454 inv01 $PINS Y=nx455 A=nx404
Xix456 inv01 $PINS Y=nx457 A=nx404
Xix458 inv01 $PINS Y=nx459 A=nx412
Xix460 inv01 $PINS Y=nx461 A=nx459
Xix462 inv01 $PINS Y=nx463 A=nx459
Xix464 inv01 $PINS Y=nx465 A=nx459
Xix379_0_XREP43_rep_1 inv01 $PINS Y=nx467 A=rst
.ENDS

.SUBCKT Reg_1 D[0] en clk rst Q[0] Qbar[0]
Xreg_Qbar_0 dffs_ni $PINS Q=Qbar[0] QB=#dummy[0] D=nx75 CLK=clk S=rst
Xix76 mux21_ni $PINS Y=nx75 A0=Qbar[0] A1=nx87 S0=en
Xix88 inv01 $PINS Y=nx87 A=D[0]
Xreg_Q_0 dffr $PINS Q=Q[0] QB=#dummy[1] D=nx65 CLK=clk R=rst
Xix66 mux21_ni $PINS Y=nx65 A0=Q[0] A1=D[0] S0=en
.ENDS

.SUBCKT ShiftReg_3 outp[3] outp[2] outp[1] outp[0] clk en rst
Xreg_outp_0 dffs_ni $PINS Q=outp[0] QB=#dummy[0] D=nx80 CLK=clk S=rst
Xix81 nor02ii $PINS Y=nx80 A0=en A1=outp[0]
Xreg_outp_1 dffr $PINS Q=outp[1] QB=#dummy[1] D=nx94 CLK=clk R=rst
Xix95 mux21_ni $PINS Y=nx94 A0=outp[1] A1=outp[0] S0=en
Xreg_outp_2 dffr $PINS Q=outp[2] QB=#dummy[2] D=nx104 CLK=clk R=rst
Xix105 mux21_ni $PINS Y=nx104 A0=outp[2] A1=outp[1] S0=en
Xreg_outp_3 dffr $PINS Q=outp[3] QB=#dummy[3] D=nx114 CLK=clk R=rst
Xix115 mux21_ni $PINS Y=nx114 A0=outp[3] A1=outp[2] S0=en
.ENDS

.SUBCKT RisingHolderHalfCycle transition clk rst f
Xreg_f dffr $PINS Q=f QB=#dummy[0] D=nx0 CLK=transition R=nx10
Xix11 or02 $PINS Y=nx10 A0=d A1=rst
Xreg_d dff $PINS Q=d QB=#dummy[1] D=f CLK=NOT_clk
Xix31 inv01 $PINS Y=NOT_clk A=clk
.ENDS

.SUBCKT Mul8x16 q[7] q[6] q[5] q[4] q[3] q[2] q[1] q[0] m[15] m[14] m[13] m[12]
+ m[11] m[10] m[9] m[8] m[7] m[6] m[5] m[4] m[3] m[2] m[1] m[0] fMul[15]
+ fMul[14] fMul[13] fMul[12] fMul[11] fMul[10] fMul[9] fMul[8] fMul[7] fMul[6]
+ fMul[5] fMul[4] fMul[3] fMul[2] fMul[1] fMul[0] clk start rst sel
+ startAndPause
XpRegCmp Reg_33 $PINS D[32]=pBs_32 D[31]=pBs_32 D[30]=pBs_30 D[29]=pBs_29
+ D[28]=pBs_28 D[27]=pBs_27 D[26]=pBs_26 D[25]=pBs_25 D[24]=pBs_24 D[23]=pBs_23
+ D[22]=fMul[15] D[21]=fMul[14] D[20]=fMul[13] D[19]=fMul[12] D[18]=fMul[11]
+ D[17]=fMul[10] D[16]=fMul[9] D[15]=fMul[8] D[14]=fMul[7] D[13]=fMul[6]
+ D[12]=fMul[5] D[11]=fMul[4] D[10]=fMul[3] D[9]=fMul[2] D[8]=fMul[1]
+ D[7]=fMul[0] D[6]=pMux_8 D[5]=pMux_7 D[4]=pMux_6 D[3]=pMux_5 D[2]=pMux_4
+ D[1]=pMux_3 D[0]=pMux_2 en=startAndPause clk=clk rst=rst Q[32]=pReg_32
+ Q[31]=pReg_31 Q[30]=pReg_30 Q[29]=pReg_29 Q[28]=pReg_28 Q[27]=pReg_27
+ Q[26]=pReg_26 Q[25]=pReg_25 Q[24]=pReg_24 Q[23]=pReg_23 Q[22]=pReg_22
+ Q[21]=pReg_21 Q[20]=pReg_20 Q[19]=pReg_19 Q[18]=pReg_18 Q[17]=pReg_17
+ Q[16]=pReg_16 Q[15]=pReg_15 Q[14]=pReg_14 Q[13]=pReg_13 Q[12]=pReg_12
+ Q[11]=pReg_11 Q[10]=pReg_10 Q[9]=pReg_9 Q[8]=pReg_8 Q[7]=pReg_7 Q[6]=pReg_6
+ Q[5]=pReg_5 Q[4]=pReg_4 Q[3]=pReg_3 Q[2]=pReg_2 Q[1]=pReg_1 Q[0]=pReg_0
+ Qbar[32]=#dummy[0] Qbar[31]=#dummy[1] Qbar[30]=#dummy[2] Qbar[29]=#dummy[3]
+ Qbar[28]=#dummy[4] Qbar[27]=#dummy[5] Qbar[26]=#dummy[6] Qbar[25]=#dummy[7]
+ Qbar[24]=#dummy[8] Qbar[23]=#dummy[9] Qbar[22]=#dummy[10] Qbar[21]=#dummy[11]
+ Qbar[20]=#dummy[12] Qbar[19]=#dummy[13] Qbar[18]=#dummy[14] Qbar[17]=#dummy[15]
+ Qbar[16]=#dummy[16] Qbar[15]=#dummy[17] Qbar[14]=#dummy[18] Qbar[13]=#dummy[19]
+ Qbar[12]=#dummy[20] Qbar[11]=#dummy[21] Qbar[10]=#dummy[22] Qbar[9]=#dummy[23]
+ Qbar[8]=#dummy[24] Qbar[7]=#dummy[25] Qbar[6]=#dummy[26] Qbar[5]=#dummy[27]
+ Qbar[4]=#dummy[28] Qbar[3]=#dummy[29] Qbar[2]=#dummy[30] Qbar[1]=#dummy[31]
+ Qbar[0]=#dummy[32]
XmRegCmp Reg_16 $PINS D[15]=m[15] D[14]=m[14] D[13]=m[13] D[12]=m[12]
+ D[11]=m[11] D[10]=m[10] D[9]=m[9] D[8]=m[8] D[7]=m[7] D[6]=m[6] D[5]=m[5]
+ D[4]=m[4] D[3]=m[3] D[2]=m[2] D[1]=m[1] D[0]=m[0] en=PWR clk=start rst=rst
+ Q[15]=mReg_15 Q[14]=mReg_14 Q[13]=mReg_13 Q[12]=mReg_12 Q[11]=mReg_11
+ Q[10]=mReg_10 Q[9]=mReg_9 Q[8]=mReg_8 Q[7]=mReg_7 Q[6]=mReg_6 Q[5]=mReg_5
+ Q[4]=mReg_4 Q[3]=mReg_3 Q[2]=mReg_2 Q[1]=mReg_1 Q[0]=mReg_0 Qbar[15]=#dummy[33]
+ Qbar[14]=#dummy[34] Qbar[13]=#dummy[35] Qbar[12]=#dummy[36] Qbar[11]=#dummy[37]
+ Qbar[10]=#dummy[38] Qbar[9]=#dummy[39] Qbar[8]=#dummy[40] Qbar[7]=#dummy[41]
+ Qbar[6]=#dummy[42] Qbar[5]=#dummy[43] Qbar[4]=#dummy[44] Qbar[3]=#dummy[45]
+ Qbar[2]=#dummy[46] Qbar[1]=#dummy[47] Qbar[0]=#dummy[48]
XqRegCmp Reg_8 $PINS D[7]=q[7] D[6]=q[6] D[5]=q[5] D[4]=q[4] D[3]=q[3]
+ D[2]=q[2] D[1]=q[1] D[0]=q[0] en=PWR clk=start rst=rst Q[7]=pInit_8
+ Q[6]=pInit_7 Q[5]=pInit_6 Q[4]=pInit_5 Q[3]=pInit_4 Q[2]=pInit_3 Q[1]=pInit_2
+ Q[0]=pInit_1 Qbar[7]=#dummy[49] Qbar[6]=#dummy[50] Qbar[5]=#dummy[51]
+ Qbar[4]=#dummy[52] Qbar[3]=#dummy[53] Qbar[2]=#dummy[54] Qbar[1]=#dummy[55]
+ Qbar[0]=#dummy[56]
XMuxCmp BinaryMux_33 $PINS a[32]=pReg_32 a[31]=pReg_31 a[30]=pReg_30
+ a[29]=pReg_29 a[28]=pReg_28 a[27]=pReg_27 a[26]=pReg_26 a[25]=pReg_25
+ a[24]=pReg_24 a[23]=pReg_23 a[22]=pReg_22 a[21]=pReg_21 a[20]=pReg_20
+ a[19]=pReg_19 a[18]=pReg_18 a[17]=pReg_17 a[16]=pReg_16 a[15]=pReg_15
+ a[14]=pReg_14 a[13]=pReg_13 a[12]=pReg_12 a[11]=pReg_11 a[10]=pReg_10
+ a[9]=pReg_9 a[8]=pReg_8 a[7]=pReg_7 a[6]=pReg_6 a[5]=pReg_5 a[4]=pReg_4
+ a[3]=pReg_3 a[2]=pReg_2 a[1]=pReg_1 a[0]=pReg_0 b[32]=pInit_32 b[31]=pInit_32
+ b[30]=pInit_32 b[29]=pInit_32 b[28]=pInit_32 b[27]=pInit_32 b[26]=pInit_32
+ b[25]=pInit_32 b[24]=pInit_32 b[23]=pInit_32 b[22]=pInit_32 b[21]=pInit_32
+ b[20]=pInit_32 b[19]=pInit_32 b[18]=pInit_32 b[17]=pInit_32 b[16]=pInit_32
+ b[15]=pInit_32 b[14]=pInit_32 b[13]=pInit_32 b[12]=pInit_32 b[11]=pInit_32
+ b[10]=pInit_32 b[9]=pInit_32 b[8]=pInit_8 b[7]=pInit_7 b[6]=pInit_6
+ b[5]=pInit_5 b[4]=pInit_4 b[3]=pInit_3 b[2]=pInit_2 b[1]=pInit_1 b[0]=pInit_32
+ sel=sel f[32]=pMux_32 f[31]=pMux_31 f[30]=pMux_30 f[29]=pMux_29 f[28]=pMux_28
+ f[27]=pMux_27 f[26]=pMux_26 f[25]=pMux_25 f[24]=pMux_24 f[23]=pMux_23
+ f[22]=pMux_22 f[21]=pMux_21 f[20]=pMux_20 f[19]=pMux_19 f[18]=pMux_18
+ f[17]=pMux_17 f[16]=pMux_16 f[15]=pMux_15 f[14]=pMux_14 f[13]=pMux_13
+ f[12]=pMux_12 f[11]=pMux_11 f[10]=pMux_10 f[9]=pMux_9 f[8]=pMux_8 f[7]=pMux_7
+ f[6]=pMux_6 f[5]=pMux_5 f[4]=pMux_4 f[3]=pMux_3 f[2]=pMux_2 f[1]=pMux_1
+ f[0]=pMux_0
XBSCmp BoothStep $PINS p[32]=pMux_32 p[31]=pMux_31 p[30]=pMux_30 p[29]=pMux_29
+ p[28]=pMux_28 p[27]=pMux_27 p[26]=pMux_26 p[25]=pMux_25 p[24]=pMux_24
+ p[23]=pMux_23 p[22]=pMux_22 p[21]=pMux_21 p[20]=pMux_20 p[19]=pMux_19
+ p[18]=pMux_18 p[17]=pMux_17 p[16]=pMux_16 p[15]=pMux_15 p[14]=pMux_14
+ p[13]=pMux_13 p[12]=pMux_12 p[11]=pMux_11 p[10]=pMux_10 p[9]=pMux_9 p[8]=pMux_8
+ p[7]=pMux_7 p[6]=pMux_6 p[5]=pMux_5 p[4]=pMux_4 p[3]=pMux_3 p[2]=pMux_2
+ p[1]=pMux_1 p[0]=pMux_0 x[23]=nx279 x[22]=nx279 x[21]=nx281 x[20]=nx283
+ x[19]=nx285 x[18]=nx287 x[17]=nx289 x[16]=nx291 x[15]=nx293 x[14]=mReg_14
+ x[13]=mReg_13 x[12]=mReg_12 x[11]=mReg_11 x[10]=mReg_10 x[9]=mReg_9 x[8]=mReg_8
+ x[7]=mReg_7 x[6]=mReg_6 x[5]=mReg_5 x[4]=mReg_4 x[3]=mReg_3 x[2]=mReg_2
+ x[1]=mReg_1 x[0]=mReg_0 f[32]=pBs_32 f[31]=#dummy[57] f[30]=pBs_30 f[29]=pBs_29
+ f[28]=pBs_28 f[27]=pBs_27 f[26]=pBs_26 f[25]=pBs_25 f[24]=pBs_24 f[23]=pBs_23
+ f[22]=fMul[15] f[21]=fMul[14] f[20]=fMul[13] f[19]=fMul[12] f[18]=fMul[11]
+ f[17]=fMul[10] f[16]=fMul[9] f[15]=fMul[8] f[14]=fMul[7] f[13]=fMul[6]
+ f[12]=fMul[5] f[11]=fMul[4] f[10]=fMul[3] f[9]=fMul[2] f[8]=fMul[1]
+ f[7]=fMul[0] f[6]=#dummy[58] f[5]=#dummy[59] f[4]=#dummy[60] f[3]=#dummy[61]
+ f[2]=#dummy[62] f[1]=#dummy[63] f[0]=#dummy[64]
Xix276 inv01 $PINS Y=nx277 A=mReg_15
Xix278 inv01 $PINS Y=nx279 A=nx277
Xix280 inv01 $PINS Y=nx281 A=nx277
Xix282 inv01 $PINS Y=nx283 A=nx277
Xix284 inv01 $PINS Y=nx285 A=nx277
Xix286 inv01 $PINS Y=nx287 A=nx277
Xix288 inv01 $PINS Y=nx289 A=nx277
Xix290 inv01 $PINS Y=nx291 A=nx277
Xix292 inv01 $PINS Y=nx293 A=nx277
.ENDS

.SUBCKT BoothStep p[32] p[31] p[30] p[29] p[28] p[27] p[26] p[25] p[24] p[23]
+ p[22] p[21] p[20] p[19] p[18] p[17] p[16] p[15] p[14] p[13] p[12] p[11] p[10]
+ p[9] p[8] p[7] p[6] p[5] p[4] p[3] p[2] p[1] p[0] x[23] x[22] x[21] x[20]
+ x[19] x[18] x[17] x[16] x[15] x[14] x[13] x[12] x[11] x[10] x[9] x[8] x[7]
+ x[6] x[5] x[4] x[3] x[2] x[1] x[0] f[32] f[31] f[30] f[29] f[28] f[27] f[26]
+ f[25] f[24] f[23] f[22] f[21] f[20] f[19] f[18] f[17] f[16] f[15] f[14] f[13]
+ f[12] f[11] f[10] f[9] f[8] f[7] f[6] f[5] f[4] f[3] f[2] f[1] f[0]
*.CONNECT f[31] f[32]
*.CONNECT f[6] p[8]
*.CONNECT f[5] p[7]
*.CONNECT f[4] p[6]
*.CONNECT f[3] p[5]
*.CONNECT f[2] p[4]
*.CONNECT f[1] p[3]
*.CONNECT f[0] p[2]
XAdderCmp NBitAdder_24 $PINS a[23]=p[32] a[22]=p[31] a[21]=p[30] a[20]=p[29]
+ a[19]=p[28] a[18]=p[27] a[17]=p[26] a[16]=p[25] a[15]=p[24] a[14]=p[23]
+ a[13]=p[22] a[12]=p[21] a[11]=p[20] a[10]=p[19] a[9]=p[18] a[8]=p[17]
+ a[7]=p[16] a[6]=p[15] a[5]=p[14] a[4]=p[13] a[3]=p[12] a[2]=p[11] a[1]=p[10]
+ a[0]=p[9] b[23]=op2_23 b[22]=op2_22 b[21]=op2_21 b[20]=op2_20 b[19]=op2_19
+ b[18]=op2_18 b[17]=op2_17 b[16]=op2_16 b[15]=op2_15 b[14]=op2_14 b[13]=op2_13
+ b[12]=op2_12 b[11]=op2_11 b[10]=op2_10 b[9]=op2_9 b[8]=op2_8 b[7]=op2_7
+ b[6]=op2_6 b[5]=op2_5 b[4]=op2_4 b[3]=op2_3 b[2]=op2_2 b[1]=op2_1 b[0]=op2_0
+ carryIn=carryIn sum[23]=f[30] sum[22]=f[29] sum[21]=f[28] sum[20]=f[27]
+ sum[19]=f[26] sum[18]=f[25] sum[17]=f[24] sum[16]=f[23] sum[15]=f[22]
+ sum[14]=f[21] sum[13]=f[20] sum[12]=f[19] sum[11]=f[18] sum[10]=f[17]
+ sum[9]=f[16] sum[8]=f[15] sum[7]=f[14] sum[6]=f[13] sum[5]=f[12] sum[4]=f[11]
+ sum[3]=f[10] sum[2]=f[9] sum[1]=f[8] sum[0]=f[7] carryOut=#dummy[0]
Xix59 oai221 $PINS Y=op2_1 A0=x[0] A1=nx435 B0=x[1] B1=nx445 C0=nx307
Xix308 aoi22 $PINS Y=nx307 A0=x[1] A1=nx414 B0=x[0] B1=nx425
Xix29 nor02_2x $PINS Y=nx28 A0=p[2] A1=nx311
Xix312 xnor2 $PINS Y=nx311 A0=p[0] A1=p[1]
Xix77 oai221 $PINS Y=op2_2 A0=x[1] A1=nx435 B0=x[2] B1=nx445 C0=nx317
Xix318 aoi22 $PINS Y=nx317 A0=x[2] A1=nx414 B0=x[1] B1=nx425
Xix95 oai221 $PINS Y=op2_3 A0=x[2] A1=nx435 B0=x[3] B1=nx445 C0=nx321
Xix322 aoi22 $PINS Y=nx321 A0=x[3] A1=nx414 B0=x[2] B1=nx425
Xix113 oai221 $PINS Y=op2_4 A0=x[3] A1=nx435 B0=x[4] B1=nx445 C0=nx325
Xix326 aoi22 $PINS Y=nx325 A0=x[4] A1=nx414 B0=x[3] B1=nx425
Xix131 oai221 $PINS Y=op2_5 A0=x[4] A1=nx435 B0=x[5] B1=nx445 C0=nx329
Xix330 aoi22 $PINS Y=nx329 A0=x[5] A1=nx414 B0=x[4] B1=nx425
Xix149 oai221 $PINS Y=op2_6 A0=x[5] A1=nx435 B0=x[6] B1=nx445 C0=nx333
Xix334 aoi22 $PINS Y=nx333 A0=x[6] A1=nx414 B0=x[5] B1=nx425
Xix167 oai221 $PINS Y=op2_7 A0=x[6] A1=nx437 B0=x[7] B1=nx445 C0=nx337
Xix338 aoi22 $PINS Y=nx337 A0=x[7] A1=nx414 B0=x[6] B1=nx425
Xix185 oai221 $PINS Y=op2_8 A0=x[7] A1=nx437 B0=x[8] B1=nx447 C0=nx341
Xix342 aoi22 $PINS Y=nx341 A0=x[8] A1=nx416 B0=x[7] B1=nx427
Xix203 oai221 $PINS Y=op2_9 A0=x[8] A1=nx437 B0=x[9] B1=nx447 C0=nx345
Xix346 aoi22 $PINS Y=nx345 A0=x[9] A1=nx416 B0=x[8] B1=nx427
Xix221 oai221 $PINS Y=op2_10 A0=x[9] A1=nx437 B0=x[10] B1=nx447 C0=nx349
Xix350 aoi22 $PINS Y=nx349 A0=x[10] A1=nx416 B0=x[9] B1=nx427
Xix239 oai221 $PINS Y=op2_11 A0=x[10] A1=nx437 B0=x[11] B1=nx447 C0=nx353
Xix354 aoi22 $PINS Y=nx353 A0=x[11] A1=nx416 B0=x[10] B1=nx427
Xix257 oai221 $PINS Y=op2_12 A0=x[11] A1=nx437 B0=x[12] B1=nx447 C0=nx357
Xix358 aoi22 $PINS Y=nx357 A0=x[12] A1=nx416 B0=x[11] B1=nx427
Xix275 oai221 $PINS Y=op2_13 A0=x[12] A1=nx437 B0=x[13] B1=nx447 C0=nx361
Xix362 aoi22 $PINS Y=nx361 A0=x[13] A1=nx416 B0=x[12] B1=nx427
Xix293 oai221 $PINS Y=op2_14 A0=x[13] A1=nx439 B0=x[14] B1=nx447 C0=nx365
Xix366 aoi22 $PINS Y=nx365 A0=x[14] A1=nx416 B0=x[13] B1=nx427
Xix311 oai221 $PINS Y=op2_15 A0=x[14] A1=nx439 B0=x[15] B1=nx449 C0=nx369
Xix370 aoi22 $PINS Y=nx369 A0=x[15] A1=nx418 B0=x[14] B1=nx429
Xix329 oai221 $PINS Y=op2_16 A0=x[15] A1=nx439 B0=x[16] B1=nx449 C0=nx373
Xix374 aoi22 $PINS Y=nx373 A0=x[16] A1=nx418 B0=x[15] B1=nx429
Xix347 oai221 $PINS Y=op2_17 A0=x[16] A1=nx439 B0=x[17] B1=nx449 C0=nx377
Xix378 aoi22 $PINS Y=nx377 A0=x[17] A1=nx418 B0=x[16] B1=nx429
Xix365 oai221 $PINS Y=op2_18 A0=x[17] A1=nx439 B0=x[18] B1=nx449 C0=nx381
Xix382 aoi22 $PINS Y=nx381 A0=x[18] A1=nx418 B0=x[17] B1=nx429
Xix383 oai221 $PINS Y=op2_19 A0=x[18] A1=nx439 B0=x[19] B1=nx449 C0=nx385
Xix386 aoi22 $PINS Y=nx385 A0=x[19] A1=nx418 B0=x[18] B1=nx429
Xix401 oai221 $PINS Y=op2_20 A0=x[19] A1=nx439 B0=x[20] B1=nx449 C0=nx389
Xix390 aoi22 $PINS Y=nx389 A0=x[20] A1=nx418 B0=x[19] B1=nx429
Xix419 oai221 $PINS Y=op2_21 A0=x[20] A1=nx441 B0=x[21] B1=nx449 C0=nx393
Xix394 aoi22 $PINS Y=nx393 A0=x[21] A1=nx418 B0=x[20] B1=nx429
Xix437 oai221 $PINS Y=op2_22 A0=x[21] A1=nx441 B0=x[22] B1=nx451 C0=nx397
Xix398 aoi22 $PINS Y=nx397 A0=x[22] A1=nx421 B0=x[21] B1=nx431
Xix455 oai221 $PINS Y=op2_23 A0=x[22] A1=nx441 B0=x[23] B1=nx451 C0=nx401
Xix402 aoi22 $PINS Y=nx401 A0=x[23] A1=nx421 B0=x[22] B1=nx431
Xix35 nand02 $PINS Y=op2_0 A0=nx405 A1=nx441
Xix408 inv01 $PINS Y=nx407 A=nx28
Xix413 inv02 $PINS Y=nx414 A=nx407
Xix415 inv02 $PINS Y=nx416 A=nx407
Xix417 inv02 $PINS Y=nx418 A=nx407
Xix420 inv02 $PINS Y=nx421 A=nx407
Xix424 inv02 $PINS Y=nx425 A=nx423
Xix426 inv02 $PINS Y=nx427 A=nx423
Xix428 inv02 $PINS Y=nx429 A=nx423
Xix430 inv02 $PINS Y=nx431 A=nx423
Xix434 inv02 $PINS Y=nx435 A=nx433
Xix436 inv02 $PINS Y=nx437 A=nx433
Xix438 inv02 $PINS Y=nx439 A=nx433
Xix440 inv02 $PINS Y=nx441 A=nx433
Xix444 inv02 $PINS Y=nx445 A=nx443
Xix446 inv02 $PINS Y=nx447 A=nx458
Xix448 inv02 $PINS Y=nx449 A=nx458
Xix450 inv02 $PINS Y=nx451 A=nx458
Xix296 nor03_2x $PINS Y=nx433 A0=p[1] A1=nx305 A2=p[0]
Xix302 nor02ii $PINS Y=nx443 A0=nx433 A1=carryIn
Xix51 nand03 $PINS Y=nx423 A0=p[1] A1=nx305 A2=p[0]
Xix406 mux21 $PINS Y=nx405 A0=nx458 A1=nx28 S0=x[0]
Xix457 inv01 $PINS Y=nx458 A=nx445
Xreg_nx305 inv02 $PINS Y=nx305 A=p[2]
Xreg_carryIn aoi21 $PINS Y=carryIn A0=p[1] A1=p[0] B0=nx305
.ENDS

.SUBCKT NBitAdder_24 a[23] a[22] a[21] a[20] a[19] a[18] a[17] a[16] a[15]
+ a[14] a[13] a[12] a[11] a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1]
+ a[0] b[23] b[22] b[21] b[20] b[19] b[18] b[17] b[16] b[15] b[14] b[13] b[12]
+ b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2] b[1] b[0] carryIn sum[23]
+ sum[22] sum[21] sum[20] sum[19] sum[18] sum[17] sum[16] sum[15] sum[14]
+ sum[13] sum[12] sum[11] sum[10] sum[9] sum[8] sum[7] sum[6] sum[5] sum[4]
+ sum[3] sum[2] sum[1] sum[0] carryOut
Xf0 FullAdder $PINS a=a[0] b=b[0] cin=carryIn s=sum[0] cout=temp_0
Xloop1_1_fx FullAdder $PINS a=a[1] b=b[1] cin=temp_0 s=sum[1] cout=temp_1
Xloop1_2_fx FullAdder $PINS a=a[2] b=b[2] cin=temp_1 s=sum[2] cout=temp_2
Xloop1_3_fx FullAdder $PINS a=a[3] b=b[3] cin=temp_2 s=sum[3] cout=temp_3
Xloop1_4_fx FullAdder $PINS a=a[4] b=b[4] cin=temp_3 s=sum[4] cout=temp_4
Xloop1_5_fx FullAdder $PINS a=a[5] b=b[5] cin=temp_4 s=sum[5] cout=temp_5
Xloop1_6_fx FullAdder $PINS a=a[6] b=b[6] cin=temp_5 s=sum[6] cout=temp_6
Xloop1_7_fx FullAdder $PINS a=a[7] b=b[7] cin=temp_6 s=sum[7] cout=temp_7
Xloop1_8_fx FullAdder $PINS a=a[8] b=b[8] cin=temp_7 s=sum[8] cout=temp_8
Xloop1_9_fx FullAdder $PINS a=a[9] b=b[9] cin=temp_8 s=sum[9] cout=temp_9
Xloop1_10_fx FullAdder $PINS a=a[10] b=b[10] cin=temp_9 s=sum[10] cout=temp_10
Xloop1_11_fx FullAdder $PINS a=a[11] b=b[11] cin=temp_10 s=sum[11] cout=temp_11
Xloop1_12_fx FullAdder $PINS a=a[12] b=b[12] cin=temp_11 s=sum[12] cout=temp_12
Xloop1_13_fx FullAdder $PINS a=a[13] b=b[13] cin=temp_12 s=sum[13] cout=temp_13
Xloop1_14_fx FullAdder $PINS a=a[14] b=b[14] cin=temp_13 s=sum[14] cout=temp_14
Xloop1_15_fx FullAdder $PINS a=a[15] b=b[15] cin=temp_14 s=sum[15] cout=temp_15
Xloop1_16_fx FullAdder $PINS a=a[16] b=b[16] cin=temp_15 s=sum[16] cout=temp_16
Xloop1_17_fx FullAdder $PINS a=a[17] b=b[17] cin=temp_16 s=sum[17] cout=temp_17
Xloop1_18_fx FullAdder $PINS a=a[18] b=b[18] cin=temp_17 s=sum[18] cout=temp_18
Xloop1_19_fx FullAdder $PINS a=a[19] b=b[19] cin=temp_18 s=sum[19] cout=temp_19
Xloop1_20_fx FullAdder $PINS a=a[20] b=b[20] cin=temp_19 s=sum[20] cout=temp_20
Xloop1_21_fx FullAdder $PINS a=a[21] b=b[21] cin=temp_20 s=sum[21] cout=temp_21
Xloop1_22_fx FullAdder $PINS a=a[22] b=b[22] cin=temp_21 s=sum[22] cout=temp_22
Xloop1_23_fx FullAdder $PINS a=a[23] b=b[23] cin=temp_22 s=sum[23]
+ cout=carryOut
.ENDS

.SUBCKT BinaryMux_33 a[32] a[31] a[30] a[29] a[28] a[27] a[26] a[25] a[24]
+ a[23] a[22] a[21] a[20] a[19] a[18] a[17] a[16] a[15] a[14] a[13] a[12] a[11]
+ a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] b[32] b[31] b[30]
+ b[29] b[28] b[27] b[26] b[25] b[24] b[23] b[22] b[21] b[20] b[19] b[18] b[17]
+ b[16] b[15] b[14] b[13] b[12] b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3]
+ b[2] b[1] b[0] sel f[32] f[31] f[30] f[29] f[28] f[27] f[26] f[25] f[24]
+ f[23] f[22] f[21] f[20] f[19] f[18] f[17] f[16] f[15] f[14] f[13] f[12] f[11]
+ f[10] f[9] f[8] f[7] f[6] f[5] f[4] f[3] f[2] f[1] f[0]
Xix15 mux21_ni $PINS Y=f[1] A0=a[1] A1=b[1] S0=nx314
Xix23 mux21_ni $PINS Y=f[2] A0=a[2] A1=b[2] S0=nx314
Xix31 mux21_ni $PINS Y=f[3] A0=a[3] A1=b[3] S0=nx314
Xix39 mux21_ni $PINS Y=f[4] A0=a[4] A1=b[4] S0=nx314
Xix47 mux21_ni $PINS Y=f[5] A0=a[5] A1=b[5] S0=nx314
Xix55 mux21_ni $PINS Y=f[6] A0=a[6] A1=b[6] S0=nx314
Xix63 mux21_ni $PINS Y=f[7] A0=a[7] A1=b[7] S0=nx302
Xix71 mux21_ni $PINS Y=f[8] A0=a[8] A1=b[8] S0=nx302
Xix79 mux21_ni $PINS Y=f[9] A0=a[9] A1=b[9] S0=nx302
Xix87 mux21_ni $PINS Y=f[10] A0=a[10] A1=b[10] S0=nx302
Xix95 mux21_ni $PINS Y=f[11] A0=a[11] A1=b[11] S0=nx302
Xix103 mux21_ni $PINS Y=f[12] A0=a[12] A1=b[12] S0=nx302
Xix111 mux21_ni $PINS Y=f[13] A0=a[13] A1=b[13] S0=nx302
Xix119 mux21_ni $PINS Y=f[14] A0=a[14] A1=b[14] S0=nx304
Xix127 mux21_ni $PINS Y=f[15] A0=a[15] A1=b[15] S0=nx304
Xix135 mux21_ni $PINS Y=f[16] A0=a[16] A1=b[16] S0=nx304
Xix143 mux21_ni $PINS Y=f[17] A0=a[17] A1=b[17] S0=nx304
Xix151 mux21_ni $PINS Y=f[18] A0=a[18] A1=b[18] S0=nx304
Xix159 mux21_ni $PINS Y=f[19] A0=a[19] A1=b[19] S0=nx304
Xix167 mux21_ni $PINS Y=f[20] A0=a[20] A1=b[20] S0=nx304
Xix175 mux21_ni $PINS Y=f[21] A0=a[21] A1=b[21] S0=nx306
Xix183 mux21_ni $PINS Y=f[22] A0=a[22] A1=b[22] S0=nx306
Xix191 mux21_ni $PINS Y=f[23] A0=a[23] A1=b[23] S0=nx306
Xix199 mux21_ni $PINS Y=f[24] A0=a[24] A1=b[24] S0=nx306
Xix207 mux21_ni $PINS Y=f[25] A0=a[25] A1=b[25] S0=nx306
Xix215 mux21_ni $PINS Y=f[26] A0=a[26] A1=b[26] S0=nx306
Xix223 mux21_ni $PINS Y=f[27] A0=a[27] A1=b[27] S0=nx306
Xix231 mux21_ni $PINS Y=f[28] A0=a[28] A1=b[28] S0=nx308
Xix239 mux21_ni $PINS Y=f[29] A0=a[29] A1=b[29] S0=nx308
Xix247 mux21_ni $PINS Y=f[30] A0=a[30] A1=b[30] S0=nx308
Xix255 mux21_ni $PINS Y=f[31] A0=a[31] A1=b[31] S0=nx308
Xix263 mux21_ni $PINS Y=f[32] A0=a[32] A1=b[32] S0=nx308
Xix301 inv02 $PINS Y=nx302 A=nx298
Xix303 inv02 $PINS Y=nx304 A=nx298
Xix305 inv02 $PINS Y=nx306 A=nx298
Xix307 inv02 $PINS Y=nx308 A=nx298
Xreg_nx298 inv02 $PINS Y=nx298 A=sel
Xreg_f_0 ao22 $PINS Y=f[0] A0=a[0] A1=nx298 B0=b[0] B1=nx314
Xix313 inv02 $PINS Y=nx314 A=nx298
.ENDS

.SUBCKT Reg_8 D[7] D[6] D[5] D[4] D[3] D[2] D[1] D[0] en clk rst Q[7] Q[6] Q[5]
+ Q[4] Q[3] Q[2] Q[1] Q[0] Qbar[7] Qbar[6] Qbar[5] Qbar[4] Qbar[3] Qbar[2]
+ Qbar[1] Qbar[0]
Xreg_Qbar_0 dffs_ni $PINS Q=Qbar[0] QB=#dummy[0] D=nx334 CLK=nx493 S=nx485
Xix335 mux21_ni $PINS Y=nx334 A0=Qbar[0] A1=nx416 S0=en
Xix417 inv01 $PINS Y=nx416 A=D[0]
Xreg_Qbar_1 dffs_ni $PINS Q=Qbar[1] QB=#dummy[1] D=nx344 CLK=nx493 S=nx485
Xix345 mux21_ni $PINS Y=nx344 A0=Qbar[1] A1=nx421 S0=en
Xix422 inv01 $PINS Y=nx421 A=D[1]
Xreg_Qbar_2 dffs_ni $PINS Q=Qbar[2] QB=#dummy[2] D=nx354 CLK=nx493 S=nx485
Xix355 mux21_ni $PINS Y=nx354 A0=Qbar[2] A1=nx426 S0=en
Xix427 inv01 $PINS Y=nx426 A=D[2]
Xreg_Qbar_3 dffs_ni $PINS Q=Qbar[3] QB=#dummy[3] D=nx364 CLK=nx493 S=nx485
Xix365 mux21_ni $PINS Y=nx364 A0=Qbar[3] A1=nx431 S0=en
Xix432 inv01 $PINS Y=nx431 A=D[3]
Xreg_Qbar_4 dffs_ni $PINS Q=Qbar[4] QB=#dummy[4] D=nx374 CLK=nx493 S=nx485
Xix375 mux21_ni $PINS Y=nx374 A0=Qbar[4] A1=nx436 S0=en
Xix437 inv01 $PINS Y=nx436 A=D[4]
Xreg_Qbar_5 dffs_ni $PINS Q=Qbar[5] QB=#dummy[5] D=nx384 CLK=nx493 S=nx485
Xix385 mux21_ni $PINS Y=nx384 A0=Qbar[5] A1=nx441 S0=en
Xix442 inv01 $PINS Y=nx441 A=D[5]
Xreg_Qbar_6 dffs_ni $PINS Q=Qbar[6] QB=#dummy[6] D=nx394 CLK=nx493 S=nx485
Xix395 mux21_ni $PINS Y=nx394 A0=Qbar[6] A1=nx446 S0=en
Xix447 inv01 $PINS Y=nx446 A=D[6]
Xreg_Qbar_7 dffs_ni $PINS Q=Qbar[7] QB=#dummy[7] D=nx404 CLK=nx495 S=nx487
Xix405 mux21_ni $PINS Y=nx404 A0=Qbar[7] A1=nx451 S0=en
Xix452 inv01 $PINS Y=nx451 A=D[7]
Xreg_Q_0 dffr $PINS Q=Q[0] QB=#dummy[8] D=nx254 CLK=nx495 R=nx487
Xix255 mux21_ni $PINS Y=nx254 A0=Q[0] A1=D[0] S0=en
Xreg_Q_1 dffr $PINS Q=Q[1] QB=#dummy[9] D=nx264 CLK=nx495 R=nx487
Xix265 mux21_ni $PINS Y=nx264 A0=Q[1] A1=D[1] S0=en
Xreg_Q_2 dffr $PINS Q=Q[2] QB=#dummy[10] D=nx274 CLK=nx495 R=nx487
Xix275 mux21_ni $PINS Y=nx274 A0=Q[2] A1=D[2] S0=en
Xreg_Q_3 dffr $PINS Q=Q[3] QB=#dummy[11] D=nx284 CLK=nx495 R=nx487
Xix285 mux21_ni $PINS Y=nx284 A0=Q[3] A1=D[3] S0=en
Xreg_Q_4 dffr $PINS Q=Q[4] QB=#dummy[12] D=nx294 CLK=nx495 R=nx487
Xix295 mux21_ni $PINS Y=nx294 A0=Q[4] A1=D[4] S0=en
Xreg_Q_5 dffr $PINS Q=Q[5] QB=#dummy[13] D=nx304 CLK=nx495 R=nx487
Xix305 mux21_ni $PINS Y=nx304 A0=Q[5] A1=D[5] S0=en
Xreg_Q_6 dffr $PINS Q=Q[6] QB=#dummy[14] D=nx314 CLK=nx497 R=nx489
Xix315 mux21_ni $PINS Y=nx314 A0=Q[6] A1=D[6] S0=en
Xreg_Q_7 dffr $PINS Q=Q[7] QB=#dummy[15] D=nx324 CLK=nx497 R=nx489
Xix325 mux21_ni $PINS Y=nx324 A0=Q[7] A1=D[7] S0=en
Xix482 inv01 $PINS Y=nx483 A=rst
Xix484 inv02 $PINS Y=nx485 A=nx483
Xix486 inv02 $PINS Y=nx487 A=nx483
Xix488 inv02 $PINS Y=nx489 A=nx483
Xix490 inv01 $PINS Y=nx491 A=clk
Xix492 inv02 $PINS Y=nx493 A=nx491
Xix494 inv02 $PINS Y=nx495 A=nx491
Xix496 inv02 $PINS Y=nx497 A=nx491
.ENDS

.SUBCKT Reg_16 D[15] D[14] D[13] D[12] D[11] D[10] D[9] D[8] D[7] D[6] D[5]
+ D[4] D[3] D[2] D[1] D[0] en clk rst Q[15] Q[14] Q[13] Q[12] Q[11] Q[10] Q[9]
+ Q[8] Q[7] Q[6] Q[5] Q[4] Q[3] Q[2] Q[1] Q[0] Qbar[15] Qbar[14] Qbar[13]
+ Qbar[12] Qbar[11] Qbar[10] Qbar[9] Qbar[8] Qbar[7] Qbar[6] Qbar[5] Qbar[4]
+ Qbar[3] Qbar[2] Qbar[1] Qbar[0]
Xreg_Qbar_0 dffs_ni $PINS Q=Qbar[0] QB=#dummy[0] D=nx630 CLK=nx925 S=nx937
Xix631 mux21_ni $PINS Y=nx630 A0=Qbar[0] A1=nx792 S0=en
Xix793 inv01 $PINS Y=nx792 A=D[0]
Xreg_Qbar_1 dffs_ni $PINS Q=Qbar[1] QB=#dummy[1] D=nx640 CLK=nx983 S=nx937
Xix641 mux21_ni $PINS Y=nx640 A0=Qbar[1] A1=nx797 S0=en
Xix798 inv01 $PINS Y=nx797 A=D[1]
Xreg_Qbar_2 dffs_ni $PINS Q=Qbar[2] QB=#dummy[2] D=nx650 CLK=nx983 S=nx937
Xix651 mux21_ni $PINS Y=nx650 A0=Qbar[2] A1=nx802 S0=en
Xix803 inv01 $PINS Y=nx802 A=D[2]
Xreg_Qbar_3 dffs_ni $PINS Q=Qbar[3] QB=#dummy[3] D=nx660 CLK=nx983 S=nx937
Xix661 mux21_ni $PINS Y=nx660 A0=Qbar[3] A1=nx807 S0=en
Xix808 inv01 $PINS Y=nx807 A=D[3]
Xreg_Qbar_4 dffs_ni $PINS Q=Qbar[4] QB=#dummy[4] D=nx670 CLK=nx982 S=nx937
Xix671 mux21_ni $PINS Y=nx670 A0=Qbar[4] A1=nx812 S0=en
Xix813 inv01 $PINS Y=nx812 A=D[4]
Xreg_Qbar_5 dffs_ni $PINS Q=Qbar[5] QB=#dummy[5] D=nx680 CLK=nx982 S=nx937
Xix681 mux21_ni $PINS Y=nx680 A0=Qbar[5] A1=nx817 S0=en
Xix818 inv01 $PINS Y=nx817 A=D[5]
Xreg_Qbar_6 dffs_ni $PINS Q=Qbar[6] QB=#dummy[6] D=nx690 CLK=nx982 S=nx937
Xix691 mux21_ni $PINS Y=nx690 A0=Qbar[6] A1=nx822 S0=en
Xix823 inv01 $PINS Y=nx822 A=D[6]
Xreg_Qbar_7 dffs_ni $PINS Q=Qbar[7] QB=#dummy[7] D=nx700 CLK=nx927 S=nx939
Xix701 mux21_ni $PINS Y=nx700 A0=Qbar[7] A1=nx827 S0=en
Xix828 inv01 $PINS Y=nx827 A=D[7]
Xreg_Qbar_8 dffs_ni $PINS Q=Qbar[8] QB=#dummy[8] D=nx710 CLK=nx985 S=nx939
Xix711 mux21_ni $PINS Y=nx710 A0=Qbar[8] A1=nx832 S0=en
Xix833 inv01 $PINS Y=nx832 A=D[8]
Xreg_Qbar_9 dffs_ni $PINS Q=Qbar[9] QB=#dummy[9] D=nx720 CLK=nx985 S=nx939
Xix721 mux21_ni $PINS Y=nx720 A0=Qbar[9] A1=nx837 S0=en
Xix838 inv01 $PINS Y=nx837 A=D[9]
Xreg_Qbar_10 dffs_ni $PINS Q=Qbar[10] QB=#dummy[10] D=nx730 CLK=nx985 S=nx939
Xix731 mux21_ni $PINS Y=nx730 A0=Qbar[10] A1=nx842 S0=en
Xix843 inv01 $PINS Y=nx842 A=D[10]
Xreg_Qbar_11 dffs_ni $PINS Q=Qbar[11] QB=#dummy[11] D=nx740 CLK=nx984 S=nx939
Xix741 mux21_ni $PINS Y=nx740 A0=Qbar[11] A1=nx847 S0=en
Xix848 inv01 $PINS Y=nx847 A=D[11]
Xreg_Qbar_12 dffs_ni $PINS Q=Qbar[12] QB=#dummy[12] D=nx750 CLK=nx984 S=nx939
Xix751 mux21_ni $PINS Y=nx750 A0=Qbar[12] A1=nx852 S0=en
Xix853 inv01 $PINS Y=nx852 A=D[12]
Xreg_Qbar_13 dffs_ni $PINS Q=Qbar[13] QB=#dummy[13] D=nx760 CLK=nx984 S=nx939
Xix761 mux21_ni $PINS Y=nx760 A0=Qbar[13] A1=nx857 S0=en
Xix858 inv01 $PINS Y=nx857 A=D[13]
Xreg_Qbar_14 dffs_ni $PINS Q=Qbar[14] QB=#dummy[14] D=nx770 CLK=nx929 S=nx941
Xix771 mux21_ni $PINS Y=nx770 A0=Qbar[14] A1=nx862 S0=en
Xix863 inv01 $PINS Y=nx862 A=D[14]
Xreg_Qbar_15 dffs_ni $PINS Q=Qbar[15] QB=#dummy[15] D=nx780 CLK=nx929 S=nx941
Xix781 mux21_ni $PINS Y=nx780 A0=Qbar[15] A1=nx867 S0=en
Xix868 inv01 $PINS Y=nx867 A=D[15]
Xreg_Q_0 dffr $PINS Q=Q[0] QB=#dummy[16] D=nx470 CLK=nx929 R=nx941
Xix471 mux21_ni $PINS Y=nx470 A0=Q[0] A1=D[0] S0=en
Xreg_Q_1 dffr $PINS Q=Q[1] QB=#dummy[17] D=nx480 CLK=nx929 R=nx941
Xix481 mux21_ni $PINS Y=nx480 A0=Q[1] A1=D[1] S0=en
Xreg_Q_2 dffr $PINS Q=Q[2] QB=#dummy[18] D=nx490 CLK=nx929 R=nx941
Xix491 mux21_ni $PINS Y=nx490 A0=Q[2] A1=D[2] S0=en
Xreg_Q_3 dffr $PINS Q=Q[3] QB=#dummy[19] D=nx500 CLK=nx929 R=nx941
Xix501 mux21_ni $PINS Y=nx500 A0=Q[3] A1=D[3] S0=en
Xreg_Q_4 dffr $PINS Q=Q[4] QB=#dummy[20] D=nx510 CLK=nx929 R=nx941
Xix511 mux21_ni $PINS Y=nx510 A0=Q[4] A1=D[4] S0=en
Xreg_Q_5 dffr $PINS Q=Q[5] QB=#dummy[21] D=nx520 CLK=nx931 R=nx943
Xix521 mux21_ni $PINS Y=nx520 A0=Q[5] A1=D[5] S0=en
Xreg_Q_6 dffr $PINS Q=Q[6] QB=#dummy[22] D=nx530 CLK=nx931 R=nx943
Xix531 mux21_ni $PINS Y=nx530 A0=Q[6] A1=D[6] S0=en
Xreg_Q_7 dffr $PINS Q=Q[7] QB=#dummy[23] D=nx540 CLK=nx931 R=nx943
Xix541 mux21_ni $PINS Y=nx540 A0=Q[7] A1=D[7] S0=en
Xreg_Q_8 dffr $PINS Q=Q[8] QB=#dummy[24] D=nx550 CLK=nx931 R=nx943
Xix551 mux21_ni $PINS Y=nx550 A0=Q[8] A1=D[8] S0=en
Xreg_Q_9 dffr $PINS Q=Q[9] QB=#dummy[25] D=nx560 CLK=nx931 R=nx943
Xix561 mux21_ni $PINS Y=nx560 A0=Q[9] A1=D[9] S0=en
Xreg_Q_10 dffr $PINS Q=Q[10] QB=#dummy[26] D=nx570 CLK=nx931 R=nx943
Xix571 mux21_ni $PINS Y=nx570 A0=Q[10] A1=D[10] S0=en
Xreg_Q_11 dffr $PINS Q=Q[11] QB=#dummy[27] D=nx580 CLK=nx931 R=nx943
Xix581 mux21_ni $PINS Y=nx580 A0=Q[11] A1=D[11] S0=en
Xreg_Q_12 dffr $PINS Q=Q[12] QB=#dummy[28] D=nx590 CLK=nx933 R=nx945
Xix591 mux21_ni $PINS Y=nx590 A0=Q[12] A1=D[12] S0=en
Xreg_Q_13 dffr $PINS Q=Q[13] QB=#dummy[29] D=nx600 CLK=nx933 R=nx945
Xix601 mux21_ni $PINS Y=nx600 A0=Q[13] A1=D[13] S0=en
Xreg_Q_14 dffr $PINS Q=Q[14] QB=#dummy[30] D=nx610 CLK=nx933 R=nx945
Xix611 mux21_ni $PINS Y=nx610 A0=Q[14] A1=D[14] S0=en
Xreg_Q_15 dffr $PINS Q=Q[15] QB=#dummy[31] D=nx620 CLK=nx933 R=nx945
Xix621 mux21_ni $PINS Y=nx620 A0=Q[15] A1=D[15] S0=en
Xix928 inv02 $PINS Y=nx929 A=nx923
Xix930 inv02 $PINS Y=nx931 A=nx923
Xix932 inv02 $PINS Y=nx933 A=nx923
Xix936 inv02 $PINS Y=nx937 A=nx935
Xix938 inv02 $PINS Y=nx939 A=nx935
Xix940 inv02 $PINS Y=nx941 A=nx935_XX0_XREP23
Xix942 inv02 $PINS Y=nx943 A=nx935_XX0_XREP23
Xix944 inv02 $PINS Y=nx945 A=nx935
Xix922 inv01 $PINS Y=nx923 A=clk
Xix934 inv01 $PINS Y=nx935 A=rst
Xix934_0_XREP23 inv01 $PINS Y=nx935_XX0_XREP23 A=rst
Xix924 inv02 $PINS Y=nx925 A=nx923_XX0_XREP21
Xix926 inv02 $PINS Y=nx927 A=nx923_XX0_XREP21
Xix922_0_XREP21 inv01 $PINS Y=nx923_XX0_XREP21 A=clk
Xix986 buf04 $PINS Y=nx982 A=nx925
Xix987 buf04 $PINS Y=nx983 A=nx925
Xix988 buf04 $PINS Y=nx984 A=nx927
Xix989 buf04 $PINS Y=nx985 A=nx927
.ENDS

.SUBCKT Reg_33 D[32] D[31] D[30] D[29] D[28] D[27] D[26] D[25] D[24] D[23]
+ D[22] D[21] D[20] D[19] D[18] D[17] D[16] D[15] D[14] D[13] D[12] D[11] D[10]
+ D[9] D[8] D[7] D[6] D[5] D[4] D[3] D[2] D[1] D[0] en clk rst Q[32] Q[31]
+ Q[30] Q[29] Q[28] Q[27] Q[26] Q[25] Q[24] Q[23] Q[22] Q[21] Q[20] Q[19] Q[18]
+ Q[17] Q[16] Q[15] Q[14] Q[13] Q[12] Q[11] Q[10] Q[9] Q[8] Q[7] Q[6] Q[5] Q[4]
+ Q[3] Q[2] Q[1] Q[0] Qbar[32] Qbar[31] Qbar[30] Qbar[29] Qbar[28] Qbar[27]
+ Qbar[26] Qbar[25] Qbar[24] Qbar[23] Qbar[22] Qbar[21] Qbar[20] Qbar[19]
+ Qbar[18] Qbar[17] Qbar[16] Qbar[15] Qbar[14] Qbar[13] Qbar[12] Qbar[11]
+ Qbar[10] Qbar[9] Qbar[8] Qbar[7] Qbar[6] Qbar[5] Qbar[4] Qbar[3] Qbar[2]
+ Qbar[1] Qbar[0]
Xreg_Qbar_0 dffs_ni $PINS Q=Qbar[0] QB=#dummy[0] D=nx1259 CLK=nx1882 S=nx1904
Xix1260 mux21_ni $PINS Y=nx1259 A0=Qbar[0] A1=nx1591 S0=nx1860
Xix1592 inv01 $PINS Y=nx1591 A=D[0]
Xreg_Qbar_1 dffs_ni $PINS Q=Qbar[1] QB=#dummy[1] D=nx1269 CLK=nx1882 S=nx1904
Xix1270 mux21_ni $PINS Y=nx1269 A0=Qbar[1] A1=nx1596 S0=nx1860
Xix1597 inv01 $PINS Y=nx1596 A=D[1]
Xreg_Qbar_2 dffs_ni $PINS Q=Qbar[2] QB=#dummy[2] D=nx1279 CLK=nx1882 S=nx1904
Xix1280 mux21_ni $PINS Y=nx1279 A0=Qbar[2] A1=nx1601 S0=nx1860
Xix1602 inv01 $PINS Y=nx1601 A=D[2]
Xreg_Qbar_3 dffs_ni $PINS Q=Qbar[3] QB=#dummy[3] D=nx1289 CLK=nx1882 S=nx1904
Xix1290 mux21_ni $PINS Y=nx1289 A0=Qbar[3] A1=nx1606 S0=nx1860
Xix1607 inv01 $PINS Y=nx1606 A=D[3]
Xreg_Qbar_4 dffs_ni $PINS Q=Qbar[4] QB=#dummy[4] D=nx1299 CLK=nx1882 S=nx1904
Xix1300 mux21_ni $PINS Y=nx1299 A0=Qbar[4] A1=nx1611 S0=nx1860
Xix1612 inv01 $PINS Y=nx1611 A=D[4]
Xreg_Qbar_5 dffs_ni $PINS Q=Qbar[5] QB=#dummy[5] D=nx1309 CLK=nx1882 S=nx1904
Xix1310 mux21_ni $PINS Y=nx1309 A0=Qbar[5] A1=nx1616 S0=nx1860
Xix1617 inv01 $PINS Y=nx1616 A=D[5]
Xreg_Qbar_6 dffs_ni $PINS Q=Qbar[6] QB=#dummy[6] D=nx1319 CLK=nx1882 S=nx1904
Xix1320 mux21_ni $PINS Y=nx1319 A0=Qbar[6] A1=nx1621 S0=nx1860
Xix1622 inv01 $PINS Y=nx1621 A=D[6]
Xreg_Qbar_7 dffs_ni $PINS Q=Qbar[7] QB=#dummy[7] D=nx1329 CLK=nx1884 S=nx1906
Xix1330 mux21_ni $PINS Y=nx1329 A0=Qbar[7] A1=nx1626 S0=nx1862
Xix1627 inv01 $PINS Y=nx1626 A=D[7]
Xreg_Qbar_8 dffs_ni $PINS Q=Qbar[8] QB=#dummy[8] D=nx1339 CLK=nx1884 S=nx1906
Xix1340 mux21_ni $PINS Y=nx1339 A0=Qbar[8] A1=nx1631 S0=nx1862
Xix1632 inv01 $PINS Y=nx1631 A=D[8]
Xreg_Qbar_9 dffs_ni $PINS Q=Qbar[9] QB=#dummy[9] D=nx1349 CLK=nx1884 S=nx1906
Xix1350 mux21_ni $PINS Y=nx1349 A0=Qbar[9] A1=nx1636 S0=nx1862
Xix1637 inv01 $PINS Y=nx1636 A=D[9]
Xreg_Qbar_10 dffs_ni $PINS Q=Qbar[10] QB=#dummy[10] D=nx1359 CLK=nx1884
+ S=nx1906
Xix1360 mux21_ni $PINS Y=nx1359 A0=Qbar[10] A1=nx1641 S0=nx1862
Xix1642 inv01 $PINS Y=nx1641 A=D[10]
Xreg_Qbar_11 dffs_ni $PINS Q=Qbar[11] QB=#dummy[11] D=nx1369 CLK=nx1884
+ S=nx1906
Xix1370 mux21_ni $PINS Y=nx1369 A0=Qbar[11] A1=nx1646 S0=nx1862
Xix1647 inv01 $PINS Y=nx1646 A=D[11]
Xreg_Qbar_12 dffs_ni $PINS Q=Qbar[12] QB=#dummy[12] D=nx1379 CLK=nx1884
+ S=nx1906
Xix1380 mux21_ni $PINS Y=nx1379 A0=Qbar[12] A1=nx1651 S0=nx1862
Xix1652 inv01 $PINS Y=nx1651 A=D[12]
Xreg_Qbar_13 dffs_ni $PINS Q=Qbar[13] QB=#dummy[13] D=nx1389 CLK=nx1884
+ S=nx1906
Xix1390 mux21_ni $PINS Y=nx1389 A0=Qbar[13] A1=nx1656 S0=nx1862
Xix1657 inv01 $PINS Y=nx1656 A=D[13]
Xreg_Qbar_14 dffs_ni $PINS Q=Qbar[14] QB=#dummy[14] D=nx1399 CLK=nx1886
+ S=nx1908
Xix1400 mux21_ni $PINS Y=nx1399 A0=Qbar[14] A1=nx1661 S0=nx1864
Xix1662 inv01 $PINS Y=nx1661 A=D[14]
Xreg_Qbar_15 dffs_ni $PINS Q=Qbar[15] QB=#dummy[15] D=nx1409 CLK=nx1886
+ S=nx1908
Xix1410 mux21_ni $PINS Y=nx1409 A0=Qbar[15] A1=nx1666 S0=nx1864
Xix1667 inv01 $PINS Y=nx1666 A=D[15]
Xreg_Qbar_16 dffs_ni $PINS Q=Qbar[16] QB=#dummy[16] D=nx1419 CLK=nx1886
+ S=nx1908
Xix1420 mux21_ni $PINS Y=nx1419 A0=Qbar[16] A1=nx1671 S0=nx1864
Xix1672 inv01 $PINS Y=nx1671 A=D[16]
Xreg_Qbar_17 dffs_ni $PINS Q=Qbar[17] QB=#dummy[17] D=nx1429 CLK=nx1886
+ S=nx1908
Xix1430 mux21_ni $PINS Y=nx1429 A0=Qbar[17] A1=nx1676 S0=nx1864
Xix1677 inv01 $PINS Y=nx1676 A=D[17]
Xreg_Qbar_18 dffs_ni $PINS Q=Qbar[18] QB=#dummy[18] D=nx1439 CLK=nx1886
+ S=nx1908
Xix1440 mux21_ni $PINS Y=nx1439 A0=Qbar[18] A1=nx1681 S0=nx1864
Xix1682 inv01 $PINS Y=nx1681 A=D[18]
Xreg_Qbar_19 dffs_ni $PINS Q=Qbar[19] QB=#dummy[19] D=nx1449 CLK=nx1886
+ S=nx1908
Xix1450 mux21_ni $PINS Y=nx1449 A0=Qbar[19] A1=nx1686 S0=nx1864
Xix1687 inv01 $PINS Y=nx1686 A=D[19]
Xreg_Qbar_20 dffs_ni $PINS Q=Qbar[20] QB=#dummy[20] D=nx1459 CLK=nx1886
+ S=nx1908
Xix1460 mux21_ni $PINS Y=nx1459 A0=Qbar[20] A1=nx1691 S0=nx1864
Xix1692 inv01 $PINS Y=nx1691 A=D[20]
Xreg_Qbar_21 dffs_ni $PINS Q=Qbar[21] QB=#dummy[21] D=nx1469 CLK=nx1888
+ S=nx1910
Xix1470 mux21_ni $PINS Y=nx1469 A0=Qbar[21] A1=nx1696 S0=nx1866
Xix1697 inv01 $PINS Y=nx1696 A=D[21]
Xreg_Qbar_22 dffs_ni $PINS Q=Qbar[22] QB=#dummy[22] D=nx1479 CLK=nx1888
+ S=nx1910
Xix1480 mux21_ni $PINS Y=nx1479 A0=Qbar[22] A1=nx1701 S0=nx1866
Xix1702 inv01 $PINS Y=nx1701 A=D[22]
Xreg_Qbar_23 dffs_ni $PINS Q=Qbar[23] QB=#dummy[23] D=nx1489 CLK=nx1888
+ S=nx1910
Xix1490 mux21_ni $PINS Y=nx1489 A0=Qbar[23] A1=nx1706 S0=nx1866
Xix1707 inv01 $PINS Y=nx1706 A=D[23]
Xreg_Qbar_24 dffs_ni $PINS Q=Qbar[24] QB=#dummy[24] D=nx1499 CLK=nx1888
+ S=nx1910
Xix1500 mux21_ni $PINS Y=nx1499 A0=Qbar[24] A1=nx1711 S0=nx1866
Xix1712 inv01 $PINS Y=nx1711 A=D[24]
Xreg_Qbar_25 dffs_ni $PINS Q=Qbar[25] QB=#dummy[25] D=nx1509 CLK=nx1888
+ S=nx1910
Xix1510 mux21_ni $PINS Y=nx1509 A0=Qbar[25] A1=nx1716 S0=nx1866
Xix1717 inv01 $PINS Y=nx1716 A=D[25]
Xreg_Qbar_26 dffs_ni $PINS Q=Qbar[26] QB=#dummy[26] D=nx1519 CLK=nx1888
+ S=nx1910
Xix1520 mux21_ni $PINS Y=nx1519 A0=Qbar[26] A1=nx1721 S0=nx1866
Xix1722 inv01 $PINS Y=nx1721 A=D[26]
Xreg_Qbar_27 dffs_ni $PINS Q=Qbar[27] QB=#dummy[27] D=nx1529 CLK=nx1888
+ S=nx1910
Xix1530 mux21_ni $PINS Y=nx1529 A0=Qbar[27] A1=nx1726 S0=nx1866
Xix1727 inv01 $PINS Y=nx1726 A=D[27]
Xreg_Qbar_28 dffs_ni $PINS Q=Qbar[28] QB=#dummy[28] D=nx1539 CLK=nx1890
+ S=nx1912
Xix1540 mux21_ni $PINS Y=nx1539 A0=Qbar[28] A1=nx1731 S0=nx1868
Xix1732 inv01 $PINS Y=nx1731 A=D[28]
Xreg_Qbar_29 dffs_ni $PINS Q=Qbar[29] QB=#dummy[29] D=nx1549 CLK=nx1890
+ S=nx1912
Xix1550 mux21_ni $PINS Y=nx1549 A0=Qbar[29] A1=nx1736 S0=nx1868
Xix1737 inv01 $PINS Y=nx1736 A=D[29]
Xreg_Qbar_30 dffs_ni $PINS Q=Qbar[30] QB=#dummy[30] D=nx1559 CLK=nx1890
+ S=nx1912
Xix1560 mux21_ni $PINS Y=nx1559 A0=Qbar[30] A1=nx1741 S0=nx1868
Xix1742 inv01 $PINS Y=nx1741 A=D[30]
Xreg_Qbar_31 dffs_ni $PINS Q=Qbar[31] QB=#dummy[31] D=nx1569 CLK=nx1890
+ S=nx1912
Xix1570 mux21_ni $PINS Y=nx1569 A0=Qbar[31] A1=nx1746 S0=nx1868
Xix1747 inv01 $PINS Y=nx1746 A=D[31]
Xreg_Qbar_32 dffs_ni $PINS Q=Qbar[32] QB=#dummy[32] D=nx1579 CLK=nx1890
+ S=nx1912
Xix1580 mux21_ni $PINS Y=nx1579 A0=Qbar[32] A1=nx1751 S0=nx1868
Xix1752 inv01 $PINS Y=nx1751 A=D[32]
Xreg_Q_0 dffr $PINS Q=Q[0] QB=#dummy[33] D=nx929 CLK=nx1890 R=nx1912
Xix930 mux21_ni $PINS Y=nx929 A0=Q[0] A1=D[0] S0=nx1868
Xreg_Q_1 dffr $PINS Q=Q[1] QB=#dummy[34] D=nx939 CLK=nx1890 R=nx1912
Xix940 mux21_ni $PINS Y=nx939 A0=Q[1] A1=D[1] S0=nx1868
Xreg_Q_2 dffr $PINS Q=Q[2] QB=#dummy[35] D=nx949 CLK=nx1892 R=nx1914
Xix950 mux21_ni $PINS Y=nx949 A0=Q[2] A1=D[2] S0=nx1870
Xreg_Q_3 dffr $PINS Q=Q[3] QB=#dummy[36] D=nx959 CLK=nx1892 R=nx1914
Xix960 mux21_ni $PINS Y=nx959 A0=Q[3] A1=D[3] S0=nx1870
Xreg_Q_4 dffr $PINS Q=Q[4] QB=#dummy[37] D=nx969 CLK=nx1892 R=nx1914
Xix970 mux21_ni $PINS Y=nx969 A0=Q[4] A1=D[4] S0=nx1870
Xreg_Q_5 dffr $PINS Q=Q[5] QB=#dummy[38] D=nx979 CLK=nx1892 R=nx1914
Xix980 mux21_ni $PINS Y=nx979 A0=Q[5] A1=D[5] S0=nx1870
Xreg_Q_6 dffr $PINS Q=Q[6] QB=#dummy[39] D=nx989 CLK=nx1892 R=nx1914
Xix990 mux21_ni $PINS Y=nx989 A0=Q[6] A1=D[6] S0=nx1870
Xreg_Q_7 dffr $PINS Q=Q[7] QB=#dummy[40] D=nx999 CLK=nx1892 R=nx1914
Xix1000 mux21_ni $PINS Y=nx999 A0=Q[7] A1=D[7] S0=nx1870
Xreg_Q_8 dffr $PINS Q=Q[8] QB=#dummy[41] D=nx1009 CLK=nx1892 R=nx1914
Xix1010 mux21_ni $PINS Y=nx1009 A0=Q[8] A1=D[8] S0=nx1870
Xreg_Q_9 dffr $PINS Q=Q[9] QB=#dummy[42] D=nx1019 CLK=nx1894 R=nx1916
Xix1020 mux21_ni $PINS Y=nx1019 A0=Q[9] A1=D[9] S0=nx1872
Xreg_Q_10 dffr $PINS Q=Q[10] QB=#dummy[43] D=nx1029 CLK=nx1894 R=nx1916
Xix1030 mux21_ni $PINS Y=nx1029 A0=Q[10] A1=D[10] S0=nx1872
Xreg_Q_11 dffr $PINS Q=Q[11] QB=#dummy[44] D=nx1039 CLK=nx1894 R=nx1916
Xix1040 mux21_ni $PINS Y=nx1039 A0=Q[11] A1=D[11] S0=nx1872
Xreg_Q_12 dffr $PINS Q=Q[12] QB=#dummy[45] D=nx1049 CLK=nx1894 R=nx1916
Xix1050 mux21_ni $PINS Y=nx1049 A0=Q[12] A1=D[12] S0=nx1872
Xreg_Q_13 dffr $PINS Q=Q[13] QB=#dummy[46] D=nx1059 CLK=nx1894 R=nx1916
Xix1060 mux21_ni $PINS Y=nx1059 A0=Q[13] A1=D[13] S0=nx1872
Xreg_Q_14 dffr $PINS Q=Q[14] QB=#dummy[47] D=nx1069 CLK=nx1894 R=nx1916
Xix1070 mux21_ni $PINS Y=nx1069 A0=Q[14] A1=D[14] S0=nx1872
Xreg_Q_15 dffr $PINS Q=Q[15] QB=#dummy[48] D=nx1079 CLK=nx1894 R=nx1916
Xix1080 mux21_ni $PINS Y=nx1079 A0=Q[15] A1=D[15] S0=nx1872
Xreg_Q_16 dffr $PINS Q=Q[16] QB=#dummy[49] D=nx1089 CLK=nx1896 R=nx1918
Xix1090 mux21_ni $PINS Y=nx1089 A0=Q[16] A1=D[16] S0=nx1874
Xreg_Q_17 dffr $PINS Q=Q[17] QB=#dummy[50] D=nx1099 CLK=nx1896 R=nx1918
Xix1100 mux21_ni $PINS Y=nx1099 A0=Q[17] A1=D[17] S0=nx1874
Xreg_Q_18 dffr $PINS Q=Q[18] QB=#dummy[51] D=nx1109 CLK=nx1896 R=nx1918
Xix1110 mux21_ni $PINS Y=nx1109 A0=Q[18] A1=D[18] S0=nx1874
Xreg_Q_19 dffr $PINS Q=Q[19] QB=#dummy[52] D=nx1119 CLK=nx1896 R=nx1918
Xix1120 mux21_ni $PINS Y=nx1119 A0=Q[19] A1=D[19] S0=nx1874
Xreg_Q_20 dffr $PINS Q=Q[20] QB=#dummy[53] D=nx1129 CLK=nx1896 R=nx1918
Xix1130 mux21_ni $PINS Y=nx1129 A0=Q[20] A1=D[20] S0=nx1874
Xreg_Q_21 dffr $PINS Q=Q[21] QB=#dummy[54] D=nx1139 CLK=nx1896 R=nx1918
Xix1140 mux21_ni $PINS Y=nx1139 A0=Q[21] A1=D[21] S0=nx1874
Xreg_Q_22 dffr $PINS Q=Q[22] QB=#dummy[55] D=nx1149 CLK=nx1896 R=nx1918
Xix1150 mux21_ni $PINS Y=nx1149 A0=Q[22] A1=D[22] S0=nx1874
Xreg_Q_23 dffr $PINS Q=Q[23] QB=#dummy[56] D=nx1159 CLK=nx1898 R=nx1920
Xix1160 mux21_ni $PINS Y=nx1159 A0=Q[23] A1=D[23] S0=nx1876
Xreg_Q_24 dffr $PINS Q=Q[24] QB=#dummy[57] D=nx1169 CLK=nx1898 R=nx1920
Xix1170 mux21_ni $PINS Y=nx1169 A0=Q[24] A1=D[24] S0=nx1876
Xreg_Q_25 dffr $PINS Q=Q[25] QB=#dummy[58] D=nx1179 CLK=nx1898 R=nx1920
Xix1180 mux21_ni $PINS Y=nx1179 A0=Q[25] A1=D[25] S0=nx1876
Xreg_Q_26 dffr $PINS Q=Q[26] QB=#dummy[59] D=nx1189 CLK=nx1898 R=nx1920
Xix1190 mux21_ni $PINS Y=nx1189 A0=Q[26] A1=D[26] S0=nx1876
Xreg_Q_27 dffr $PINS Q=Q[27] QB=#dummy[60] D=nx1199 CLK=nx1898 R=nx1920
Xix1200 mux21_ni $PINS Y=nx1199 A0=Q[27] A1=D[27] S0=nx1876
Xreg_Q_28 dffr $PINS Q=Q[28] QB=#dummy[61] D=nx1209 CLK=nx1898 R=nx1920
Xix1210 mux21_ni $PINS Y=nx1209 A0=Q[28] A1=D[28] S0=nx1876
Xreg_Q_29 dffr $PINS Q=Q[29] QB=#dummy[62] D=nx1219 CLK=nx1898 R=nx1920
Xix1220 mux21_ni $PINS Y=nx1219 A0=Q[29] A1=D[29] S0=nx1876
Xreg_Q_30 dffr $PINS Q=Q[30] QB=#dummy[63] D=nx1229 CLK=nx1900 R=nx1922
Xix1230 mux21_ni $PINS Y=nx1229 A0=Q[30] A1=D[30] S0=nx1878
Xreg_Q_31 dffr $PINS Q=Q[31] QB=#dummy[64] D=nx1239 CLK=nx1900 R=nx1922
Xix1240 mux21_ni $PINS Y=nx1239 A0=Q[31] A1=D[31] S0=nx1878
Xreg_Q_32 dffr $PINS Q=Q[32] QB=#dummy[65] D=nx1249 CLK=nx1900 R=nx1922
Xix1250 mux21_ni $PINS Y=nx1249 A0=Q[32] A1=D[32] S0=nx1878
Xix1859 inv02 $PINS Y=nx1860 A=nx1924_XX0_XREP13
Xix1861 inv02 $PINS Y=nx1862 A=nx1924_XX0_XREP13
Xix1863 inv02 $PINS Y=nx1864 A=nx1924
Xix1865 inv02 $PINS Y=nx1866 A=nx1924
Xix1867 inv02 $PINS Y=nx1868 A=nx1924
Xix1869 inv02 $PINS Y=nx1870 A=nx1858_XX0_XREP17
Xix1871 inv02 $PINS Y=nx1872 A=nx1858_XX0_XREP17
Xix1873 inv02 $PINS Y=nx1874 A=nx1858
Xix1875 inv02 $PINS Y=nx1876 A=nx1858
Xix1877 inv02 $PINS Y=nx1878 A=nx1858
Xix1879 inv01 $PINS Y=nx1880 A=clk
Xix1881 inv02 $PINS Y=nx1882 A=nx1926
Xix1883 inv02 $PINS Y=nx1884 A=nx1926
Xix1885 inv02 $PINS Y=nx1886 A=nx1926
Xix1887 inv02 $PINS Y=nx1888 A=nx1926
Xix1889 inv02 $PINS Y=nx1890 A=nx1926
Xix1891 inv02 $PINS Y=nx1892 A=nx1880
Xix1893 inv02 $PINS Y=nx1894 A=nx1880
Xix1895 inv02 $PINS Y=nx1896 A=nx1880
Xix1897 inv02 $PINS Y=nx1898 A=nx1880
Xix1899 inv02 $PINS Y=nx1900 A=nx1880
Xix1903 inv02 $PINS Y=nx1904 A=nx1928
Xix1905 inv02 $PINS Y=nx1906 A=nx1928_XX0_XREP15
Xix1907 inv02 $PINS Y=nx1908 A=nx1928
Xix1909 inv02 $PINS Y=nx1910 A=nx1928
Xix1911 inv02 $PINS Y=nx1912 A=nx1928_XX0_XREP15
Xix1913 inv02 $PINS Y=nx1914 A=nx1902_XX0_XREP19
Xix1915 inv02 $PINS Y=nx1916 A=nx1902_XX0_XREP19
Xix1917 inv02 $PINS Y=nx1918 A=nx1902
Xix1919 inv02 $PINS Y=nx1920 A=nx1902
Xix1921 inv02 $PINS Y=nx1922 A=nx1902
Xix1925 inv01 $PINS Y=nx1926 A=clk
Xix1923 inv01 $PINS Y=nx1924 A=en
Xix1923_0_XREP13 inv01 $PINS Y=nx1924_XX0_XREP13 A=en
Xix1927 inv01 $PINS Y=nx1928 A=rst
Xix1927_0_XREP15 inv01 $PINS Y=nx1928_XX0_XREP15 A=rst
Xix1857 inv01 $PINS Y=nx1858 A=en
Xix1857_0_XREP17 inv01 $PINS Y=nx1858_XX0_XREP17 A=en
Xix1901 inv01 $PINS Y=nx1902 A=rst
Xix1901_0_XREP19 inv01 $PINS Y=nx1902_XX0_XREP19 A=rst
.ENDS

.SUBCKT ngetMax_16_10 inputArray_9__15 inputArray_9__14 inputArray_9__13
+ inputArray_9__12 inputArray_9__11 inputArray_9__10 inputArray_9__9
+ inputArray_9__8 inputArray_9__7 inputArray_9__6 inputArray_9__5
+ inputArray_9__4 inputArray_9__3 inputArray_9__2 inputArray_9__1
+ inputArray_9__0 inputArray_8__15 inputArray_8__14 inputArray_8__13
+ inputArray_8__12 inputArray_8__11 inputArray_8__10 inputArray_8__9
+ inputArray_8__8 inputArray_8__7 inputArray_8__6 inputArray_8__5
+ inputArray_8__4 inputArray_8__3 inputArray_8__2 inputArray_8__1
+ inputArray_8__0 inputArray_7__15 inputArray_7__14 inputArray_7__13
+ inputArray_7__12 inputArray_7__11 inputArray_7__10 inputArray_7__9
+ inputArray_7__8 inputArray_7__7 inputArray_7__6 inputArray_7__5
+ inputArray_7__4 inputArray_7__3 inputArray_7__2 inputArray_7__1
+ inputArray_7__0 inputArray_6__15 inputArray_6__14 inputArray_6__13
+ inputArray_6__12 inputArray_6__11 inputArray_6__10 inputArray_6__9
+ inputArray_6__8 inputArray_6__7 inputArray_6__6 inputArray_6__5
+ inputArray_6__4 inputArray_6__3 inputArray_6__2 inputArray_6__1
+ inputArray_6__0 inputArray_5__15 inputArray_5__14 inputArray_5__13
+ inputArray_5__12 inputArray_5__11 inputArray_5__10 inputArray_5__9
+ inputArray_5__8 inputArray_5__7 inputArray_5__6 inputArray_5__5
+ inputArray_5__4 inputArray_5__3 inputArray_5__2 inputArray_5__1
+ inputArray_5__0 inputArray_4__15 inputArray_4__14 inputArray_4__13
+ inputArray_4__12 inputArray_4__11 inputArray_4__10 inputArray_4__9
+ inputArray_4__8 inputArray_4__7 inputArray_4__6 inputArray_4__5
+ inputArray_4__4 inputArray_4__3 inputArray_4__2 inputArray_4__1
+ inputArray_4__0 inputArray_3__15 inputArray_3__14 inputArray_3__13
+ inputArray_3__12 inputArray_3__11 inputArray_3__10 inputArray_3__9
+ inputArray_3__8 inputArray_3__7 inputArray_3__6 inputArray_3__5
+ inputArray_3__4 inputArray_3__3 inputArray_3__2 inputArray_3__1
+ inputArray_3__0 inputArray_2__15 inputArray_2__14 inputArray_2__13
+ inputArray_2__12 inputArray_2__11 inputArray_2__10 inputArray_2__9
+ inputArray_2__8 inputArray_2__7 inputArray_2__6 inputArray_2__5
+ inputArray_2__4 inputArray_2__3 inputArray_2__2 inputArray_2__1
+ inputArray_2__0 inputArray_1__15 inputArray_1__14 inputArray_1__13
+ inputArray_1__12 inputArray_1__11 inputArray_1__10 inputArray_1__9
+ inputArray_1__8 inputArray_1__7 inputArray_1__6 inputArray_1__5
+ inputArray_1__4 inputArray_1__3 inputArray_1__2 inputArray_1__1
+ inputArray_1__0 inputArray_0__15 inputArray_0__14 inputArray_0__13
+ inputArray_0__12 inputArray_0__11 inputArray_0__10 inputArray_0__9
+ inputArray_0__8 inputArray_0__7 inputArray_0__6 inputArray_0__5
+ inputArray_0__4 inputArray_0__3 inputArray_0__2 inputArray_0__1
+ inputArray_0__0 en clk rst outLabel[3] outLabel[2] outLabel[1] outLabel[0]
+ done
XregMaxValue RegTony_16 $PINS D[15]=regMaxin_15 D[14]=regMaxin_14
+ D[13]=regMaxin_13 D[12]=regMaxin_12 D[11]=regMaxin_11 D[10]=regMaxin_10
+ D[9]=regMaxin_9 D[8]=regMaxin_8 D[7]=regMaxin_7 D[6]=regMaxin_6 D[5]=regMaxin_5
+ D[4]=regMaxin_4 D[3]=regMaxin_3 D[2]=regMaxin_2 D[1]=regMaxin_1 D[0]=regMaxin_0
+ load[15]=PWR load[14]=GND load[13]=GND load[12]=GND load[11]=GND load[10]=GND
+ load[9]=GND load[8]=GND load[7]=GND load[6]=GND load[5]=GND load[4]=GND
+ load[3]=GND load[2]=GND load[1]=GND load[0]=GND en=en clk=clk rst=nx1073
+ Q[15]=regMaxout_15 Q[14]=regMaxout_14 Q[13]=regMaxout_13 Q[12]=regMaxout_12
+ Q[11]=regMaxout_11 Q[10]=regMaxout_10 Q[9]=regMaxout_9 Q[8]=regMaxout_8
+ Q[7]=regMaxout_7 Q[6]=regMaxout_6 Q[5]=regMaxout_5 Q[4]=regMaxout_4
+ Q[3]=regMaxout_3 Q[2]=regMaxout_2 Q[1]=regMaxout_1 Q[0]=regMaxout_0
+ Qbar[15]=#dummy[0] Qbar[14]=#dummy[1] Qbar[13]=#dummy[2] Qbar[12]=#dummy[3]
+ Qbar[11]=#dummy[4] Qbar[10]=#dummy[5] Qbar[9]=#dummy[6] Qbar[8]=#dummy[7]
+ Qbar[7]=#dummy[8] Qbar[6]=#dummy[9] Qbar[5]=#dummy[10] Qbar[4]=#dummy[11]
+ Qbar[3]=#dummy[12] Qbar[2]=#dummy[13] Qbar[1]=#dummy[14] Qbar[0]=#dummy[15]
XregMaxIndex RegTony_4 $PINS D[3]=indexMaxin_3 D[2]=indexMaxin_2
+ D[1]=indexMaxin_1 D[0]=indexMaxin_0 load[3]=GND load[2]=GND load[1]=GND
+ load[0]=GND en=en clk=clk rst=nx1069 Q[3]=outLabel[3] Q[2]=outLabel[2]
+ Q[1]=outLabel[1] Q[0]=outLabel[0] Qbar[3]=#dummy[16] Qbar[2]=#dummy[17]
+ Qbar[1]=#dummy[18] Qbar[0]=#dummy[19]
XCounterLabel CounterUpDown_4 $PINS load[3]=GND load[2]=GND load[1]=GND
+ load[0]=GND resetValue[3]=GND resetValue[2]=GND resetValue[1]=GND
+ resetValue[0]=GND clk=clk en=en rst=nx1071 isLoad=GND upOrDown=GND
+ count[3]=Count_3 count[2]=Count_2 count[1]=Count_1 count[0]=Count_0
XComparatorLabel Comparator_16 $PINS inputA[15]=regMaxout_15
+ inputA[14]=regMaxout_14 inputA[13]=regMaxout_13 inputA[12]=regMaxout_12
+ inputA[11]=regMaxout_11 inputA[10]=regMaxout_10 inputA[9]=regMaxout_9
+ inputA[8]=regMaxout_8 inputA[7]=regMaxout_7 inputA[6]=regMaxout_6
+ inputA[5]=regMaxout_5 inputA[4]=regMaxout_4 inputA[3]=regMaxout_3
+ inputA[2]=regMaxout_2 inputA[1]=regMaxout_1 inputA[0]=regMaxout_0
+ inputB[15]=InputBcomparator_15 inputB[14]=InputBcomparator_14
+ inputB[13]=InputBcomparator_13 inputB[12]=InputBcomparator_12
+ inputB[11]=InputBcomparator_11 inputB[10]=InputBcomparator_10
+ inputB[9]=InputBcomparator_9 inputB[8]=InputBcomparator_8
+ inputB[7]=InputBcomparator_7 inputB[6]=InputBcomparator_6
+ inputB[5]=InputBcomparator_5 inputB[4]=InputBcomparator_4
+ inputB[3]=InputBcomparator_3 inputB[2]=InputBcomparator_2
+ inputB[1]=InputBcomparator_1 inputB[0]=InputBcomparator_0 outputG=ComparatorG
+ outputEqual=#dummy[20]
Xix702 inv02 $PINS Y=nx701 A=Count_1
Xix704 inv02 $PINS Y=nx703 A=Count_3
Xlat_InputBcomparator_0 latch $PINS Q=InputBcomparator_0 D=nx178 CLK=nx961
Xix179 nand04 $PINS Y=nx178 A0=nx709 A1=nx715 A2=nx727 A3=nx733
Xix710 aoi22 $PINS Y=nx709 A0=inputArray_8__0 A1=nx1039 B0=inputArray_0__0
+ B1=nx1033
Xix716 aoi222 $PINS Y=nx715 A0=inputArray_3__0 A1=nx1025 B0=inputArray_4__0
+ B1=nx1017 C0=inputArray_5__0 C1=nx1009
Xix720 inv02 $PINS Y=nx719 A=Count_0
Xix728 aoi22 $PINS Y=nx727 A0=inputArray_6__0 A1=nx1001 B0=inputArray_7__0
+ B1=nx993
Xix734 aoi222 $PINS Y=nx733 A0=inputArray_9__0 A1=nx969 B0=inputArray_1__0
+ B1=nx985 C0=inputArray_2__0 C1=nx977
Xix742 inv02 $PINS Y=nx741 A=Count_2
Xlat_InputBcomparator_1 latch $PINS Q=InputBcomparator_1 D=nx232 CLK=nx961
Xix233 nand04 $PINS Y=nx232 A0=nx747 A1=nx749 A2=nx751 A3=nx753
Xix748 aoi22 $PINS Y=nx747 A0=inputArray_8__1 A1=nx1039 B0=inputArray_0__1
+ B1=nx1033
Xix750 aoi222 $PINS Y=nx749 A0=inputArray_3__1 A1=nx1025 B0=inputArray_4__1
+ B1=nx1017 C0=inputArray_5__1 C1=nx1009
Xix752 aoi22 $PINS Y=nx751 A0=inputArray_6__1 A1=nx1001 B0=inputArray_7__1
+ B1=nx993
Xix754 aoi222 $PINS Y=nx753 A0=inputArray_9__1 A1=nx969 B0=inputArray_1__1
+ B1=nx985 C0=inputArray_2__1 C1=nx977
Xlat_InputBcomparator_2 latch $PINS Q=InputBcomparator_2 D=nx282 CLK=nx961
Xix283 nand04 $PINS Y=nx282 A0=nx759 A1=nx761 A2=nx763 A3=nx765
Xix760 aoi22 $PINS Y=nx759 A0=inputArray_8__2 A1=nx1039 B0=inputArray_0__2
+ B1=nx1033
Xix762 aoi222 $PINS Y=nx761 A0=inputArray_3__2 A1=nx1025 B0=inputArray_4__2
+ B1=nx1017 C0=inputArray_5__2 C1=nx1009
Xix764 aoi22 $PINS Y=nx763 A0=inputArray_6__2 A1=nx1001 B0=inputArray_7__2
+ B1=nx993
Xix766 aoi222 $PINS Y=nx765 A0=inputArray_9__2 A1=nx969 B0=inputArray_1__2
+ B1=nx985 C0=inputArray_2__2 C1=nx977
Xlat_InputBcomparator_3 latch $PINS Q=InputBcomparator_3 D=nx332 CLK=nx961
Xix333 nand04 $PINS Y=nx332 A0=nx771 A1=nx773 A2=nx775 A3=nx777
Xix772 aoi22 $PINS Y=nx771 A0=inputArray_8__3 A1=nx1039 B0=inputArray_0__3
+ B1=nx1033
Xix774 aoi222 $PINS Y=nx773 A0=inputArray_3__3 A1=nx1025 B0=inputArray_4__3
+ B1=nx1017 C0=inputArray_5__3 C1=nx1009
Xix776 aoi22 $PINS Y=nx775 A0=inputArray_6__3 A1=nx1001 B0=inputArray_7__3
+ B1=nx993
Xix778 aoi222 $PINS Y=nx777 A0=inputArray_9__3 A1=nx969 B0=inputArray_1__3
+ B1=nx985 C0=inputArray_2__3 C1=nx977
Xlat_InputBcomparator_4 latch $PINS Q=InputBcomparator_4 D=nx382 CLK=nx961
Xix383 nand04 $PINS Y=nx382 A0=nx783 A1=nx785 A2=nx787 A3=nx789
Xix784 aoi22 $PINS Y=nx783 A0=inputArray_8__4 A1=nx1039 B0=inputArray_0__4
+ B1=nx1033
Xix786 aoi222 $PINS Y=nx785 A0=inputArray_3__4 A1=nx1025 B0=inputArray_4__4
+ B1=nx1017 C0=inputArray_5__4 C1=nx1009
Xix788 aoi22 $PINS Y=nx787 A0=inputArray_6__4 A1=nx1001 B0=inputArray_7__4
+ B1=nx993
Xix790 aoi222 $PINS Y=nx789 A0=inputArray_9__4 A1=nx969 B0=inputArray_1__4
+ B1=nx985 C0=inputArray_2__4 C1=nx977
Xlat_InputBcomparator_5 latch $PINS Q=InputBcomparator_5 D=nx432 CLK=nx961
Xix433 nand04 $PINS Y=nx432 A0=nx795 A1=nx797 A2=nx799 A3=nx801
Xix796 aoi22 $PINS Y=nx795 A0=inputArray_8__5 A1=nx1039 B0=inputArray_0__5
+ B1=nx1033
Xix798 aoi222 $PINS Y=nx797 A0=inputArray_3__5 A1=nx1025 B0=inputArray_4__5
+ B1=nx1017 C0=inputArray_5__5 C1=nx1009
Xix800 aoi22 $PINS Y=nx799 A0=inputArray_6__5 A1=nx1001 B0=inputArray_7__5
+ B1=nx993
Xix802 aoi222 $PINS Y=nx801 A0=inputArray_9__5 A1=nx969 B0=inputArray_1__5
+ B1=nx985 C0=inputArray_2__5 C1=nx977
Xlat_InputBcomparator_6 latch $PINS Q=InputBcomparator_6 D=nx482 CLK=nx961
Xix483 nand04 $PINS Y=nx482 A0=nx807 A1=nx809 A2=nx811 A3=nx813
Xix808 aoi22 $PINS Y=nx807 A0=inputArray_8__6 A1=nx1039 B0=inputArray_0__6
+ B1=nx1033
Xix810 aoi222 $PINS Y=nx809 A0=inputArray_3__6 A1=nx1025 B0=inputArray_4__6
+ B1=nx1017 C0=inputArray_5__6 C1=nx1009
Xix812 aoi22 $PINS Y=nx811 A0=inputArray_6__6 A1=nx1001 B0=inputArray_7__6
+ B1=nx993
Xix814 aoi222 $PINS Y=nx813 A0=inputArray_9__6 A1=nx969 B0=inputArray_1__6
+ B1=nx985 C0=inputArray_2__6 C1=nx977
Xlat_InputBcomparator_7 latch $PINS Q=InputBcomparator_7 D=nx532 CLK=nx963
Xix533 nand04 $PINS Y=nx532 A0=nx819 A1=nx821 A2=nx823 A3=nx825
Xix820 aoi22 $PINS Y=nx819 A0=inputArray_8__7 A1=nx1041 B0=inputArray_0__7
+ B1=nx1035
Xix822 aoi222 $PINS Y=nx821 A0=inputArray_3__7 A1=nx1027 B0=inputArray_4__7
+ B1=nx1019 C0=inputArray_5__7 C1=nx1011
Xix824 aoi22 $PINS Y=nx823 A0=inputArray_6__7 A1=nx1003 B0=inputArray_7__7
+ B1=nx995
Xix826 aoi222 $PINS Y=nx825 A0=inputArray_9__7 A1=nx971 B0=inputArray_1__7
+ B1=nx987 C0=inputArray_2__7 C1=nx979
Xlat_InputBcomparator_8 latch $PINS Q=InputBcomparator_8 D=nx582 CLK=nx963
Xix583 nand04 $PINS Y=nx582 A0=nx831 A1=nx833 A2=nx835 A3=nx837
Xix832 aoi22 $PINS Y=nx831 A0=inputArray_8__8 A1=nx1041 B0=inputArray_0__8
+ B1=nx1035
Xix834 aoi222 $PINS Y=nx833 A0=inputArray_3__8 A1=nx1027 B0=inputArray_4__8
+ B1=nx1019 C0=inputArray_5__8 C1=nx1011
Xix836 aoi22 $PINS Y=nx835 A0=inputArray_6__8 A1=nx1003 B0=inputArray_7__8
+ B1=nx995
Xix838 aoi222 $PINS Y=nx837 A0=inputArray_9__8 A1=nx971 B0=inputArray_1__8
+ B1=nx987 C0=inputArray_2__8 C1=nx979
Xlat_InputBcomparator_9 latch $PINS Q=InputBcomparator_9 D=nx632 CLK=nx963
Xix633 nand04 $PINS Y=nx632 A0=nx841 A1=nx843 A2=nx845 A3=nx847
Xix842 aoi22 $PINS Y=nx841 A0=inputArray_8__9 A1=nx1041 B0=inputArray_0__9
+ B1=nx1035
Xix844 aoi222 $PINS Y=nx843 A0=inputArray_3__9 A1=nx1027 B0=inputArray_4__9
+ B1=nx1019 C0=inputArray_5__9 C1=nx1011
Xix846 aoi22 $PINS Y=nx845 A0=inputArray_6__9 A1=nx1003 B0=inputArray_7__9
+ B1=nx995
Xix848 aoi222 $PINS Y=nx847 A0=inputArray_9__9 A1=nx971 B0=inputArray_1__9
+ B1=nx987 C0=inputArray_2__9 C1=nx979
Xlat_InputBcomparator_10 latch $PINS Q=InputBcomparator_10 D=nx682 CLK=nx963
Xix683 nand04 $PINS Y=nx682 A0=nx853 A1=nx855 A2=nx857 A3=nx859
Xix854 aoi22 $PINS Y=nx853 A0=inputArray_8__10 A1=nx1041 B0=inputArray_0__10
+ B1=nx1035
Xix856 aoi222 $PINS Y=nx855 A0=inputArray_3__10 A1=nx1027 B0=inputArray_4__10
+ B1=nx1019 C0=inputArray_5__10 C1=nx1011
Xix858 aoi22 $PINS Y=nx857 A0=inputArray_6__10 A1=nx1003 B0=inputArray_7__10
+ B1=nx995
Xix860 aoi222 $PINS Y=nx859 A0=inputArray_9__10 A1=nx971 B0=inputArray_1__10
+ B1=nx987 C0=inputArray_2__10 C1=nx979
Xlat_InputBcomparator_11 latch $PINS Q=InputBcomparator_11 D=nx732 CLK=nx963
Xix733 nand04 $PINS Y=nx732 A0=nx865 A1=nx867 A2=nx869 A3=nx871
Xix866 aoi22 $PINS Y=nx865 A0=inputArray_8__11 A1=nx1041 B0=inputArray_0__11
+ B1=nx1035
Xix868 aoi222 $PINS Y=nx867 A0=inputArray_3__11 A1=nx1027 B0=inputArray_4__11
+ B1=nx1019 C0=inputArray_5__11 C1=nx1011
Xix870 aoi22 $PINS Y=nx869 A0=inputArray_6__11 A1=nx1003 B0=inputArray_7__11
+ B1=nx995
Xix872 aoi222 $PINS Y=nx871 A0=inputArray_9__11 A1=nx971 B0=inputArray_1__11
+ B1=nx987 C0=inputArray_2__11 C1=nx979
Xlat_InputBcomparator_12 latch $PINS Q=InputBcomparator_12 D=nx782 CLK=nx963
Xix783 nand04 $PINS Y=nx782 A0=nx877 A1=nx879 A2=nx881 A3=nx883
Xix878 aoi22 $PINS Y=nx877 A0=inputArray_8__12 A1=nx1041 B0=inputArray_0__12
+ B1=nx1035
Xix880 aoi222 $PINS Y=nx879 A0=inputArray_3__12 A1=nx1027 B0=inputArray_4__12
+ B1=nx1019 C0=inputArray_5__12 C1=nx1011
Xix882 aoi22 $PINS Y=nx881 A0=inputArray_6__12 A1=nx1003 B0=inputArray_7__12
+ B1=nx995
Xix884 aoi222 $PINS Y=nx883 A0=inputArray_9__12 A1=nx971 B0=inputArray_1__12
+ B1=nx987 C0=inputArray_2__12 C1=nx979
Xlat_InputBcomparator_13 latch $PINS Q=InputBcomparator_13 D=nx832 CLK=nx963
Xix833 nand04 $PINS Y=nx832 A0=nx887 A1=nx889 A2=nx891 A3=nx893
Xix888 aoi22 $PINS Y=nx887 A0=inputArray_8__13 A1=nx1041 B0=inputArray_0__13
+ B1=nx1035
Xix890 aoi222 $PINS Y=nx889 A0=inputArray_3__13 A1=nx1027 B0=inputArray_4__13
+ B1=nx1019 C0=inputArray_5__13 C1=nx1011
Xix892 aoi22 $PINS Y=nx891 A0=inputArray_6__13 A1=nx1003 B0=inputArray_7__13
+ B1=nx995
Xix894 aoi222 $PINS Y=nx893 A0=inputArray_9__13 A1=nx971 B0=inputArray_1__13
+ B1=nx987 C0=inputArray_2__13 C1=nx979
Xlat_InputBcomparator_14 latch $PINS Q=InputBcomparator_14 D=nx882 CLK=nx965
Xix883 nand04 $PINS Y=nx882 A0=nx897 A1=nx899 A2=nx901 A3=nx903
Xix898 aoi22 $PINS Y=nx897 A0=inputArray_8__14 A1=nx108 B0=inputArray_0__14
+ B1=nx1037
Xix900 aoi222 $PINS Y=nx899 A0=inputArray_3__14 A1=nx1029 B0=inputArray_4__14
+ B1=nx1021 C0=inputArray_5__14 C1=nx1013
Xix902 aoi22 $PINS Y=nx901 A0=inputArray_6__14 A1=nx1005 B0=inputArray_7__14
+ B1=nx997
Xix904 aoi222 $PINS Y=nx903 A0=inputArray_9__14 A1=nx973 B0=inputArray_1__14
+ B1=nx989 C0=inputArray_2__14 C1=nx981
Xlat_InputBcomparator_15 latch $PINS Q=InputBcomparator_15 D=nx116 CLK=nx965
Xix117 nand04 $PINS Y=nx116 A0=nx909 A1=nx911 A2=nx913 A3=nx915
Xix910 aoi22 $PINS Y=nx909 A0=inputArray_8__15 A1=nx108 B0=inputArray_0__15
+ B1=nx1037
Xix912 aoi222 $PINS Y=nx911 A0=inputArray_3__15 A1=nx1029 B0=inputArray_4__15
+ B1=nx1021 C0=inputArray_5__15 C1=nx1013
Xix914 aoi22 $PINS Y=nx913 A0=inputArray_6__15 A1=nx1005 B0=inputArray_7__15
+ B1=nx997
Xix916 aoi222 $PINS Y=nx915 A0=inputArray_9__15 A1=nx973 B0=inputArray_1__15
+ B1=nx989 C0=inputArray_2__15 C1=nx981
Xix193 ao22 $PINS Y=regMaxin_0 A0=regMaxout_0 A1=nx1089 B0=InputBcomparator_0
+ B1=nx1093
Xix243 ao22 $PINS Y=regMaxin_1 A0=regMaxout_1 A1=nx1089 B0=InputBcomparator_1
+ B1=nx1093
Xix293 ao22 $PINS Y=regMaxin_2 A0=regMaxout_2 A1=nx1089 B0=InputBcomparator_2
+ B1=nx1093
Xix343 ao22 $PINS Y=regMaxin_3 A0=regMaxout_3 A1=nx1089 B0=InputBcomparator_3
+ B1=nx1093
Xix393 ao22 $PINS Y=regMaxin_4 A0=regMaxout_4 A1=nx1089 B0=InputBcomparator_4
+ B1=nx1093
Xix443 ao22 $PINS Y=regMaxin_5 A0=regMaxout_5 A1=nx1089 B0=InputBcomparator_5
+ B1=nx1093
Xix493 ao22 $PINS Y=regMaxin_6 A0=regMaxout_6 A1=nx1089 B0=InputBcomparator_6
+ B1=nx1093
Xix543 ao22 $PINS Y=regMaxin_7 A0=regMaxout_7 A1=nx1091 B0=InputBcomparator_7
+ B1=nx1095
Xix593 ao22 $PINS Y=regMaxin_8 A0=regMaxout_8 A1=nx1091 B0=InputBcomparator_8
+ B1=nx1095
Xix643 ao22 $PINS Y=regMaxin_9 A0=regMaxout_9 A1=nx1091 B0=InputBcomparator_9
+ B1=nx1095
Xix693 ao22 $PINS Y=regMaxin_10 A0=regMaxout_10 A1=nx1091
+ B0=InputBcomparator_10 B1=nx1095
Xix743 ao22 $PINS Y=regMaxin_11 A0=regMaxout_11 A1=nx1091
+ B0=InputBcomparator_11 B1=nx1095
Xix793 ao22 $PINS Y=regMaxin_12 A0=regMaxout_12 A1=nx1091
+ B0=InputBcomparator_12 B1=nx1095
Xix843 ao22 $PINS Y=regMaxin_13 A0=regMaxout_13 A1=nx1091
+ B0=InputBcomparator_13 B1=nx1095
Xix893 ao22 $PINS Y=regMaxin_14 A0=regMaxout_14 A1=nx138 B0=InputBcomparator_14
+ B1=nx188
Xix133 or02 $PINS Y=regMaxin_15 A0=nx130 A1=nx1073
Xix950 inv02 $PINS Y=nx951 A=nx703
Xix952 inv02 $PINS Y=nx953 A=nx741
Xix954 inv02 $PINS Y=nx955 A=nx701
Xix960 inv02 $PINS Y=nx961 A=nx959
Xix962 inv02 $PINS Y=nx963 A=nx959
Xix964 inv02 $PINS Y=nx965 A=nx959
Xix968 inv02 $PINS Y=nx969 A=nx967
Xix970 inv02 $PINS Y=nx971 A=nx967
Xix972 inv02 $PINS Y=nx973 A=nx967
Xix976 inv02 $PINS Y=nx977 A=nx975
Xix978 inv02 $PINS Y=nx979 A=nx975
Xix980 inv02 $PINS Y=nx981 A=nx975
Xix984 inv02 $PINS Y=nx985 A=nx983
Xix986 inv02 $PINS Y=nx987 A=nx983
Xix988 inv02 $PINS Y=nx989 A=nx983
Xix992 inv02 $PINS Y=nx993 A=nx991
Xix994 inv02 $PINS Y=nx995 A=nx991
Xix996 inv02 $PINS Y=nx997 A=nx991
Xix1000 inv02 $PINS Y=nx1001 A=nx999
Xix1002 inv02 $PINS Y=nx1003 A=nx999
Xix1004 inv02 $PINS Y=nx1005 A=nx999
Xix1008 inv02 $PINS Y=nx1009 A=nx1007
Xix1010 inv02 $PINS Y=nx1011 A=nx1007
Xix1012 inv02 $PINS Y=nx1013 A=nx1007
Xix1016 inv02 $PINS Y=nx1017 A=nx1015
Xix1018 inv02 $PINS Y=nx1019 A=nx1015
Xix1020 inv02 $PINS Y=nx1021 A=nx1015
Xix1024 inv02 $PINS Y=nx1025 A=nx1023
Xix1026 inv02 $PINS Y=nx1027 A=nx1023
Xix1028 inv02 $PINS Y=nx1029 A=nx1023
Xix1032 inv02 $PINS Y=nx1033 A=nx1031
Xix1034 inv02 $PINS Y=nx1035 A=nx1031
Xix1036 inv02 $PINS Y=nx1037 A=nx1031
Xix1050 inv02 $PINS Y=nx1051 A=nx1083
Xix9 and04 $PINS Y=done A0=nx1083 A1=nx1079 A2=nx741 A3=nx1077
Xix109 and02 $PINS Y=nx108 A0=nx1083 A1=nx1077
Xix103 nand04 $PINS Y=nx1031 A0=nx741 A1=nx703 A2=nx1083 A3=nx701
Xix89 nand04 $PINS Y=nx1023 A0=nx741 A1=nx703 A2=nx1081 A3=nx1079
Xix83 nand03 $PINS Y=nx1015 A0=nx1065 A1=nx1083 A2=nx701
Xix1064 inv01 $PINS Y=nx1065 A=nx723
Xix724 or02 $PINS Y=nx723 A0=nx741 A1=nx1077
Xix73 nand03 $PINS Y=nx1007 A0=nx1065 A1=nx1081 A2=nx701
Xix61 nand03 $PINS Y=nx999 A0=nx1065 A1=nx1083 A2=nx1079
Xix57 nand03 $PINS Y=nx991 A0=nx1065 A1=nx1081 A2=nx1079
Xix25 nand02 $PINS Y=nx967 A0=nx1081 A1=nx1077
Xix43 nand04 $PINS Y=nx983 A0=nx741 A1=nx703 A2=nx1081 A3=nx701
Xix35 nand04 $PINS Y=nx975 A0=nx741 A1=nx703 A2=nx1083 A3=nx1079
Xix23 ao21 $PINS Y=nx959 A0=nx739 A1=nx951 B0=nx1073
Xix740 or02 $PINS Y=nx739 A0=nx1079 A1=Count_2
Xix901 mux21_ni $PINS Y=indexMaxin_0 A0=nx1051 A1=outLabel[0] S0=nx1085
Xix909 mux21_ni $PINS Y=indexMaxin_1 A0=nx955 A1=outLabel[1] S0=nx1085
Xix917 mux21_ni $PINS Y=indexMaxin_2 A0=nx953 A1=outLabel[2] S0=nx1085
Xix925 mux21_ni $PINS Y=indexMaxin_3 A0=nx951 A1=outLabel[3] S0=nx1085
Xix139 nor02ii $PINS Y=nx138 A0=nx1073 A1=nx1085
Xix189 nor02ii $PINS Y=nx188 A0=nx1073 A1=ComparatorG
Xix131 mux21_ni $PINS Y=nx130 A0=InputBcomparator_15 A1=regMaxout_15 S0=nx1085
Xix1038 and02 $PINS Y=nx1039 A0=nx719 A1=nx1077
Xix1040 and02 $PINS Y=nx1041 A0=nx719 A1=nx1077
Xix1042 nor02ii $PINS Y=nx1043 A0=nx1073 A1=nx1085
Xix1044 nor02ii $PINS Y=nx1045 A0=nx1073 A1=nx1087
Xix1046 nor02ii $PINS Y=nx1047 A0=nx1075 A1=ComparatorG
Xix1048 nor02ii $PINS Y=nx1049 A0=nx1075 A1=ComparatorG
Xix1068 inv01 $PINS Y=nx1069 A=nx1067
Xix1070 inv01 $PINS Y=nx1071 A=nx1067
Xix1072 inv01 $PINS Y=nx1073 A=nx1067_XX0_XREP11
Xix1074 inv01 $PINS Y=nx1075 A=nx1067
Xix1076 inv02 $PINS Y=nx1077 A=nx703
Xix1078 inv02 $PINS Y=nx1079 A=nx701
Xix1080 inv01 $PINS Y=nx1081 A=nx719
Xix1082 inv02 $PINS Y=nx1083 A=Count_0
Xix1084 inv02 $PINS Y=nx1085 A=ComparatorG
Xix1086 inv02 $PINS Y=nx1087 A=ComparatorG
Xix1088 buf02 $PINS Y=nx1089 A=nx1043
Xix1090 buf02 $PINS Y=nx1091 A=nx1045
Xix1092 buf02 $PINS Y=nx1093 A=nx1047
Xix1094 buf02 $PINS Y=nx1095 A=nx1049
Xix1066 inv01 $PINS Y=nx1067 A=rst
Xix1066_0_XREP11 inv01 $PINS Y=nx1067_XX0_XREP11 A=rst
.ENDS

.SUBCKT Comparator_16 inputA[15] inputA[14] inputA[13] inputA[12] inputA[11]
+ inputA[10] inputA[9] inputA[8] inputA[7] inputA[6] inputA[5] inputA[4]
+ inputA[3] inputA[2] inputA[1] inputA[0] inputB[15] inputB[14] inputB[13]
+ inputB[12] inputB[11] inputB[10] inputB[9] inputB[8] inputB[7] inputB[6]
+ inputB[5] inputB[4] inputB[3] inputB[2] inputB[1] inputB[0] outputG
+ outputEqual
Xix93 and02 $PINS Y=outputEqual A0=nx137 A1=nx88
Xix138 xnor2 $PINS Y=nx137 A0=inputA[0] A1=inputB[0]
Xix171 oai33 $PINS Y=nx170 A0=nx209 A1=nx213 A2=inputB[12] B0=nx177 B1=nx215
+ B2=inputB[13]
Xix214 inv01 $PINS Y=nx213 A=inputA[12]
Xix216 inv01 $PINS Y=nx215 A=inputA[13]
Xlat_outputG_u1 latchs_ni $PINS QB=nx5 D=nx91 CLK=nx188 S=nx286
Xlat_outputG_u2 inv02 $PINS Y=outputG A=nx5
Xix482 inv02 $PINS Y=nx332 A=inputA[2]
Xix483 inv02 $PINS Y=nx333 A=inputA[3]
Xix484 inv02 $PINS Y=nx334 A=inputB[1]
Xix485 inv02 $PINS Y=nx335 A=inputB[0]
Xix486 aoi22 $PINS Y=nx336 A0=inputA[1] A1=nx334 B0=inputA[0] B1=nx335
Xix487 nor02ii $PINS Y=nx337 A0=inputA[1] A1=inputB[1]
Xix488 inv02 $PINS Y=nx338 A=inputA[1]
Xix489 aoi22 $PINS Y=nx339 A0=inputB[1] A1=inputA[1] B0=nx334 B1=nx338
Xreg_nx88 nor02_2x $PINS Y=nx88 A0=nx339 A1=nx372
Xix490 inv02 $PINS Y=nx340 A=nx334
Xix491 nand02_2x $PINS Y=nx341 A0=inputB[1] A1=nx338
Xix492 nor02ii $PINS Y=nx342 A0=inputA[0] A1=inputB[0]
Xix493 inv02 $PINS Y=nx343 A=inputB[0]
Xix494 inv02 $PINS Y=nx344 A=inputB[1]
Xix495 oai21 $PINS Y=nx345 A0=nx343 A1=inputA[0] B0=nx344
Xix496 inv02 $PINS Y=nx346 A=inputA[1]
Xix497 aoi32 $PINS Y=nx347 A0=nx340 A1=nx341 A2=nx342 B0=nx345 B1=nx346
Xix498 inv02 $PINS Y=nx348 A=inputB[2]
Xix499 inv02 $PINS Y=nx349 A=inputA[2]
Xix500 oai22 $PINS Y=nx350 A0=nx348 A1=inputA[2] B0=nx349 B1=inputB[2]
Xix501 inv02 $PINS Y=nx351 A=inputB[14]
Xix502 inv02 $PINS Y=nx352 A=inputA[14]
Xix503 inv02 $PINS Y=nx353 A=inputB[15]
Xix504 inv02 $PINS Y=nx354 A=inputA[15]
Xix505 inv02 $PINS Y=nx355 A=inputB[12]
Xix506 inv02 $PINS Y=nx356 A=inputA[12]
Xix507 inv02 $PINS Y=nx357 A=inputB[13]
Xix508 inv02 $PINS Y=nx358 A=inputA[13]
Xix509 oai22 $PINS Y=nx359 A0=nx358 A1=nx357 B0=inputA[13] B1=inputB[13]
Xreg_nx177 inv01 $PINS Y=nx177 A=nx417
Xix510 inv02 $PINS Y=nx360 A=inputB[4]
Xix511 inv02 $PINS Y=nx361 A=inputA[4]
Xix512 aoi22 $PINS Y=nx362 A0=inputA[4] A1=nx360 B0=nx651 B1=nx361
Xix513 inv02 $PINS Y=nx363 A=inputB[3]
Xix514 inv02 $PINS Y=nx364 A=inputA[3]
Xix515 aoi22 $PINS Y=nx365 A0=inputA[3] A1=nx363 B0=inputB[3] B1=nx364
Xix516 oai221 $PINS Y=nx366 A0=nx348 A1=inputA[2] B0=inputB[2] B1=nx349
+ C0=nx365
Xix517 inv02 $PINS Y=nx367 A=inputA[5]
Xix518 oai22 $PINS Y=nx368 A0=nx360 A1=nx361 B0=nx651 B1=inputA[4]
Xix519 aoi22 $PINS Y=nx369 A0=inputB[3] A1=inputA[3] B0=nx363 B1=nx364
Xix520 oai32 $PINS Y=nx370 A0=nx369 A1=nx332 A2=inputB[2] B0=nx333 B1=inputB[3]
Xix521 or02 $PINS Y=nx371 A0=nx336 A1=nx337
Xix522 inv01 $PINS Y=nx372 A=NOT_nx141
Xix523 inv02 $PINS Y=nx373 A=inputB[10]
Xix524 inv02 $PINS Y=nx374 A=inputA[10]
Xix525 inv02 $PINS Y=nx375 A=inputB[11]
Xix526 inv02 $PINS Y=nx376 A=inputA[11]
Xix527 oai22 $PINS Y=nx377 A0=nx375 A1=inputA[11] B0=nx376 B1=inputB[11]
Xix528 oai22 $PINS Y=nx378 A0=nx376 A1=nx375 B0=inputA[11] B1=inputB[11]
Xix529 inv02 $PINS Y=nx379 A=inputB[6]
Xix530 inv02 $PINS Y=nx380 A=inputA[6]
Xix531 aoi22 $PINS Y=nx381 A0=inputB[6] A1=inputA[6] B0=nx379 B1=nx380
Xix532 inv02 $PINS Y=nx382 A=inputB[5]
Xix533 inv02 $PINS Y=nx383 A=inputA[5]
Xix534 aoi22 $PINS Y=nx384 A0=inputB[5] A1=inputA[5] B0=nx382 B1=nx383
Xix535 oai32 $PINS Y=nx385 A0=nx637 A1=nx361 A2=nx651 B0=nx367 B1=inputB[5]
Xix536 nor02ii $PINS Y=nx386 A0=nx635 A1=nx385
Xix537 inv02 $PINS Y=nx387 A=inputA[7]
Xix538 aoi22 $PINS Y=nx388 A0=inputA[6] A1=nx379 B0=inputB[6] B1=nx380
Xix539 aoi22 $PINS Y=nx389 A0=inputA[5] A1=nx382 B0=inputB[5] B1=nx383
Xix540 inv02 $PINS Y=nx390 A=inputA[9]
Xix541 inv02 $PINS Y=nx391 A=inputB[9]
Xix542 inv02 $PINS Y=nx392 A=inputA[8]
Xix543 inv02 $PINS Y=nx393 A=inputB[8]
Xix544 inv01 $PINS Y=nx394 A=nx362
Xix545 inv02 $PINS Y=nx395 A=inputA[7]
Xix546 inv02 $PINS Y=nx396 A=inputB[7]
Xix547 aoi22 $PINS Y=nx397 A0=inputA[7] A1=inputB[7] B0=nx395 B1=nx396
Xix548 or03 $PINS Y=nx398 A0=nx635 A1=nx394 A2=nx397
Xix549 nor02_2x $PINS Y=nx399 A0=nx635 A1=nx637
Xix550 aoi22 $PINS Y=nx400 A0=inputB[7] A1=nx395 B0=inputA[7] B1=nx396
Xix551 oai22 $PINS Y=nx401 A0=nx357 A1=inputA[13] B0=nx358 B1=inputB[13]
Xix552 oai22 $PINS Y=nx402 A0=nx353 A1=inputA[15] B0=nx354 B1=nx649
Xix553 oai22 $PINS Y=nx403 A0=nx390 A1=nx391 B0=inputA[9] B1=inputB[9]
Xix554 aoi22 $PINS Y=nx404 A0=inputB[8] A1=nx392 B0=inputA[8] B1=nx393
Xix555 inv01 $PINS Y=nx405 A=nx362
Xix556 nor02_2x $PINS Y=nx406 A0=nx348 A1=inputA[2]
Xix557 inv02 $PINS Y=nx407 A=inputA[3]
Xix558 aoi44 $PINS Y=nx408 A0=nx459 A1=nx438 A2=nx365 A3=nx406 B0=nx399
+ B1=nx400 B2=inputB[3] B3=nx407
Xix559 inv01 $PINS Y=nx409 A=nx365
Xix560 inv02 $PINS Y=nx410 A=inputA[4]
Xix561 inv02 $PINS Y=nx411 A=inputA[5]
Xix562 inv01 $PINS Y=nx412 A=nx400
Xix563 inv02 $PINS Y=nx413 A=inputB[6]
Xix564 inv02 $PINS Y=nx414 A=inputB[7]
Xix565 inv01 $PINS Y=nx415 A=nx400
Xix566 oai32 $PINS Y=nx416 A0=nx415 A1=nx380 A2=inputB[6] B0=nx387 B1=inputB[7]
Xix567 aoi221 $PINS Y=nx417 A0=inputA[14] A1=nx351 B0=inputB[14] B1=nx352
+ C0=nx402
Xix568 and02 $PINS Y=nx418 A0=inputA[12] A1=nx355
Xix569 and02 $PINS Y=nx419 A0=inputB[12] A1=nx356
Xix570 nor03_2x $PINS Y=nx420 A0=nx418 A1=nx419 A2=nx401
Xix571 and02 $PINS Y=nx421 A0=inputA[10] A1=nx373
Xix572 nor02_2x $PINS Y=nx422 A0=nx641 A1=nx633
Xix573 inv02 $PINS Y=nx423 A=nx403
Xix574 inv01 $PINS Y=nx424 A=nx404
Xix575 and02 $PINS Y=nx425 A0=inputB[10] A1=nx374
Xix576 nor03_2x $PINS Y=nx426 A0=nx423 A1=nx424 A2=nx643
Xix577 and04 $PINS Y=nx427 A0=nx639 A1=nx420 A2=nx422 A3=nx426
Xix578 nor04_2x $PINS Y=nx428 A0=nx409 A1=nx405 A2=nx347 A3=nx350
Xix579 nand02_2x $PINS Y=nx429 A0=nx404 A1=nx403
Xix580 or04 $PINS Y=nx430 A0=nx397 A1=nx635 A2=nx643 A3=nx637
Xix581 nor04_2x $PINS Y=nx431 A0=nx641 A1=nx633 A2=nx429 A3=nx430
Xreg_nx72 and03 $PINS Y=nx72 A0=nx639 A1=nx431 A2=nx420
Xix582 aoi32 $PINS Y=nx432 A0=nx389 A1=nx651 A2=nx410 B0=inputB[5] B1=nx411
Xix583 inv01 $PINS Y=nx433 A=nx388
Xix584 oai32 $PINS Y=nx434 A0=nx412 A1=nx413 A2=inputA[6] B0=nx414 B1=inputA[7]
Xix585 inv01 $PINS Y=nx435 A=nx434
Xix586 oai321 $PINS Y=nx436 A0=nx432 A1=nx397 A2=nx433 B0=nx405 B1=nx408
+ C0=nx435
Xix587 aoi321 $PINS Y=nx437 A0=nx389 A1=nx651 A2=nx410 B0=inputB[5] B1=nx411
+ C0=nx428
Xix588 inv01 $PINS Y=nx438 A=nx397
Xix589 aoi21 $PINS Y=nx439 A0=nx438 A1=nx388 B0=nx428
Xix590 oai221 $PINS Y=nx440 A0=nx437 A1=nx439 B0=nx405 B1=nx408 C0=nx435
Xix591 inv02 $PINS Y=nx441 A=nx378
Xix592 nor04_2x $PINS Y=nx442 A0=nx441 A1=nx419 A2=nx418 A3=nx401
Xreg_nx48 and02 $PINS Y=nx48 A0=nx639 A1=nx442
Xix593 inv02 $PINS Y=nx443 A=inputA[10]
Xreg_nx44 and02 $PINS Y=nx44 A0=nx639 A1=nx420
Xix594 nor02ii $PINS Y=nx444 A0=inputA[11] A1=inputB[11]
Xix595 nand02_2x $PINS Y=nx445 A0=nx353 A1=nx649
Xix596 nand02_2x $PINS Y=nx446 A0=nx354 A1=nx649
Xix597 inv02 $PINS Y=nx447 A=inputB[14]
Xix598 inv02 $PINS Y=nx448 A=inputA[15]
Xix599 oai22 $PINS Y=nx449 A0=nx447 A1=inputA[14] B0=nx448 B1=nx649
Xix600 inv02 $PINS Y=nx450 A=inputA[12]
Xix601 inv02 $PINS Y=nx451 A=inputA[13]
Xix602 ao32 $PINS Y=nx452 A0=nx359 A1=inputB[12] A2=nx450 B0=inputB[13]
+ B1=nx451
Xreg_NOT_nx277 ao32 $PINS Y=NOT_nx277 A0=nx445 A1=nx446 A2=nx449 B0=nx452
+ B1=nx639
Xix603 aoi321 $PINS Y=nx453 A0=nx48 A1=inputB[10] A2=nx443 B0=nx44 B1=nx444
+ C0=NOT_nx277
Xix604 nor04_2x $PINS Y=nx454 A0=nx641 A1=nx633 A2=nx423 A3=nx643
Xreg_nx56 and03 $PINS Y=nx56 A0=nx639 A1=nx420 A2=nx454
Xix605 inv02 $PINS Y=nx455 A=inputA[8]
Xix606 nor03_2x $PINS Y=nx456 A0=nx641 A1=nx643 A2=nx633
Xreg_nx52 and03 $PINS Y=nx52 A0=nx639 A1=nx420 A2=nx456
Xix607 inv02 $PINS Y=nx457 A=inputA[9]
Xix608 aoi33 $PINS Y=nx458 A0=nx56 A1=inputB[8] A2=nx455 B0=nx52 B1=inputB[9]
+ B2=nx457
Xreg_nx286 nand03_2x $PINS Y=nx286 A0=nx481 A1=nx453 A2=nx458
Xix609 nor02_2x $PINS Y=nx459 A0=nx635 A1=nx637
Xix610 nand02_2x $PINS Y=nx460 A0=inputA[14] A1=nx351
Xix611 aoi21 $PINS Y=nx461 A0=inputB[14] A1=nx352 B0=nx402
Xreg_nx209 nand03_2x $PINS Y=nx209 A0=nx460 A1=nx359 A2=nx461
Xix612 inv02 $PINS Y=nx462 A=inputB[8]
Xix613 inv02 $PINS Y=nx463 A=inputB[9]
Xix614 aoi33 $PINS Y=nx464 A0=nx56 A1=inputA[8] A2=nx462 B0=nx52 B1=inputA[9]
+ B2=nx463
Xix615 inv02 $PINS Y=nx465 A=inputB[10]
Xix616 inv02 $PINS Y=nx466 A=inputB[11]
Xix617 aoi33 $PINS Y=nx467 A0=nx48 A1=inputA[10] A2=nx465 B0=nx44 B1=inputA[11]
+ B2=nx466
Xix618 inv02 $PINS Y=nx468 A=inputA[15]
Xix619 nand02_2x $PINS Y=nx469 A0=nx649 A1=nx468
Xix620 inv02 $PINS Y=nx470 A=inputB[14]
Xix621 nand02_2x $PINS Y=nx471 A0=inputA[14] A1=nx470
Xix622 aoi222 $PINS Y=nx472 A0=nx469 A1=nx471 B0=nx354 B1=inputA[15] C0=nx353
+ C1=inputA[15]
Xix623 nor02_2x $PINS Y=nx473 A0=nx472 A1=nx170
Xix624 inv01 $PINS Y=nx474 A=nx404
Xix625 nor02_2x $PINS Y=nx475 A0=nx474 A1=nx398
Xix626 nor03_2x $PINS Y=nx476 A0=nx637 A1=nx371 A2=nx366
Xix627 ao21 $PINS Y=nx477 A0=nx386 A1=nx438 B0=nx416
Xix628 aoi332 $PINS Y=nx478 A0=nx72 A1=nx368 A2=nx370 B0=nx56 B1=nx475 B2=nx476
+ C0=nx427 C1=nx477
Xreg_nx188 nand04_2x $PINS Y=nx188 A0=nx464 A1=nx467 A2=nx473 A3=nx478
Xix629 nor04_2x $PINS Y=nx479 A0=nx474 A1=nx398 A2=nx637 A3=nx366
Xreg_NOT_nx141 and02 $PINS Y=NOT_nx141 A0=nx56 A1=nx479
Xix630 and02 $PINS Y=nx480 A0=nx428 A1=nx72
Xix631 oai221 $PINS Y=nx481 A0=nx480 A1=nx427 B0=nx72 B1=nx436 C0=nx440
Xix632 buf02 $PINS Y=nx633 A=nx377
Xix634 buf02 $PINS Y=nx635 A=nx381
Xix636 buf02 $PINS Y=nx637 A=nx384
Xix638 inv01 $PINS Y=nx639 A=nx177
Xix640 buf02 $PINS Y=nx641 A=nx421
Xix642 buf02 $PINS Y=nx643 A=nx425
Xix648 inv02 $PINS Y=nx649 A=nx353
Xix650 inv02 $PINS Y=nx651 A=nx360
.ENDS

.SUBCKT CounterUpDown_4 load[3] load[2] load[1] load[0] resetValue[3]
+ resetValue[2] resetValue[1] resetValue[0] clk en rst isLoad upOrDown count[3]
+ count[2] count[1] count[0]
XnextCount NBitAdder_4 $PINS a[3]=count[3] a[2]=count[2] a[1]=count[1]
+ a[0]=count[0] b[3]=upOrDown b[2]=upOrDown b[1]=upOrDown b[0]=upOrDown
+ carryIn=NOT_upOrDown sum[3]=countAdded_3 sum[2]=countAdded_2
+ sum[1]=countAdded_1 sum[0]=countAdded_0 carryOut=#dummy[0]
Xix245 inv01 $PINS Y=NOT_upOrDown A=upOrDown
Xreg_currentCount_0 dffsr_ni $PINS Q=count[0] QB=#dummy[1] D=nx202 CLK=clk
+ S=nx10 R=nx14
Xix203 mux21_ni $PINS Y=nx202 A0=nx8 A1=count[0] S0=nx249
Xix9 mux21_ni $PINS Y=nx8 A0=load[0] A1=countAdded_0 S0=nx290
Xix11 and02 $PINS Y=nx10 A0=resetValue[0] A1=rst
Xreg_currentCount_1 dffsr_ni $PINS Q=count[1] QB=#dummy[2] D=nx212 CLK=clk
+ S=nx26 R=nx30
Xix213 mux21_ni $PINS Y=nx212 A0=nx24 A1=count[1] S0=nx249
Xix25 mux21_ni $PINS Y=nx24 A0=load[1] A1=countAdded_1 S0=nx290
Xix27 and02 $PINS Y=nx26 A0=resetValue[1] A1=rst
Xreg_currentCount_2 dffsr_ni $PINS Q=count[2] QB=#dummy[3] D=nx222 CLK=clk
+ S=nx42 R=nx46
Xix223 mux21_ni $PINS Y=nx222 A0=nx40 A1=count[2] S0=nx249
Xix41 mux21_ni $PINS Y=nx40 A0=load[2] A1=countAdded_2 S0=nx290
Xix43 and02 $PINS Y=nx42 A0=resetValue[2] A1=rst
Xreg_currentCount_3 dffsr_ni $PINS Q=count[3] QB=#dummy[4] D=nx232 CLK=clk
+ S=nx58 R=nx62
Xix233 mux21_ni $PINS Y=nx232 A0=nx56 A1=count[3] S0=nx249
Xix57 mux21_ni $PINS Y=nx56 A0=load[3] A1=countAdded_3 S0=nx290
Xix59 and02 $PINS Y=nx58 A0=resetValue[3] A1=rst
Xix15 nor02ii $PINS Y=nx14 A0=resetValue[0] A1=rst
Xix31 nor02ii $PINS Y=nx30 A0=resetValue[1] A1=rst
Xix47 nor02ii $PINS Y=nx46 A0=resetValue[2] A1=rst
Xix63 nor02ii $PINS Y=nx62 A0=resetValue[3] A1=rst
Xreg_nx249 nor02_2x $PINS Y=nx249 A0=isLoad A1=nx290
Xix289 buf02 $PINS Y=nx290 A=en
.ENDS

.SUBCKT NBitAdder_4 a[3] a[2] a[1] a[0] b[3] b[2] b[1] b[0] carryIn sum[3]
+ sum[2] sum[1] sum[0] carryOut
Xf0 FullAdder $PINS a=a[0] b=b[0] cin=carryIn s=sum[0] cout=temp_0
Xloop1_1_fx FullAdder $PINS a=a[1] b=b[1] cin=temp_0 s=sum[1] cout=temp_1
Xloop1_2_fx FullAdder $PINS a=a[2] b=b[2] cin=temp_1 s=sum[2] cout=temp_2
Xloop1_3_fx FullAdder $PINS a=a[3] b=b[3] cin=temp_2 s=sum[3] cout=carryOut
.ENDS

.SUBCKT RegTony_4 D[3] D[2] D[1] D[0] load[3] load[2] load[1] load[0] en clk
+ rst Q[3] Q[2] Q[1] Q[0] Qbar[3] Qbar[2] Qbar[1] Qbar[0]
Xreg_Qbar_0 dffsr_ni $PINS Q=Qbar[0] QB=#dummy[0] D=nx216 CLK=clk S=nx4 R=nx0
Xix217 mux21_ni $PINS Y=nx216 A0=Qbar[0] A1=nx260 S0=nx325
Xix261 inv01 $PINS Y=nx260 A=D[0]
Xix1 and02 $PINS Y=nx0 A0=rst A1=load[0]
Xreg_Qbar_1 dffsr_ni $PINS Q=Qbar[1] QB=#dummy[1] D=nx226 CLK=clk S=nx12 R=nx8
Xix227 mux21_ni $PINS Y=nx226 A0=Qbar[1] A1=nx269 S0=nx325
Xix270 inv01 $PINS Y=nx269 A=D[1]
Xix9 and02 $PINS Y=nx8 A0=rst A1=load[1]
Xreg_Qbar_2 dffsr_ni $PINS Q=Qbar[2] QB=#dummy[2] D=nx236 CLK=clk S=nx20 R=nx16
Xix237 mux21_ni $PINS Y=nx236 A0=Qbar[2] A1=nx276 S0=nx325
Xix277 inv01 $PINS Y=nx276 A=D[2]
Xix17 and02 $PINS Y=nx16 A0=rst A1=load[2]
Xreg_Qbar_3 dffsr_ni $PINS Q=Qbar[3] QB=#dummy[3] D=nx246 CLK=clk S=nx28 R=nx24
Xix25 and02 $PINS Y=nx24 A0=rst A1=load[3]
Xreg_Q_0 dffsr_ni $PINS Q=Q[0] QB=#dummy[4] D=nx176 CLK=clk S=nx0 R=nx4
Xix177 mux21_ni $PINS Y=nx176 A0=Q[0] A1=D[0] S0=nx325
Xreg_Q_1 dffsr_ni $PINS Q=Q[1] QB=#dummy[5] D=nx186 CLK=clk S=nx8 R=nx12
Xix187 mux21_ni $PINS Y=nx186 A0=Q[1] A1=D[1] S0=nx325
Xreg_Q_2 dffsr_ni $PINS Q=Q[2] QB=#dummy[6] D=nx196 CLK=clk S=nx16 R=nx20
Xix197 mux21_ni $PINS Y=nx196 A0=Q[2] A1=D[2] S0=nx325
Xreg_Q_3 dffsr_ni $PINS Q=Q[3] QB=#dummy[7] D=nx206 CLK=clk S=nx24 R=nx28
Xix207 mux21_ni $PINS Y=nx206 A0=Q[3] A1=D[3] S0=nx307
Xix5 nor02ii $PINS Y=nx4 A0=load[0] A1=rst
Xix13 nor02ii $PINS Y=nx12 A0=load[1] A1=rst
Xix21 nor02ii $PINS Y=nx20 A0=load[2] A1=rst
Xix29 nor02ii $PINS Y=nx28 A0=load[3] A1=rst
Xix306 buf02 $PINS Y=nx307 A=nx325
Xix322 inv02 $PINS Y=nx320 A=en
Xix323 inv02 $PINS Y=nx321 A=D[3]
Xreg_nx246 ao22 $PINS Y=nx246 A0=Qbar[3] A1=nx320 B0=nx327 B1=nx321
Xix324 inv02 $PINS Y=nx325 A=nx320
Xix326 inv02 $PINS Y=nx327 A=nx320
.ENDS

.SUBCKT RegTony_16 D[15] D[14] D[13] D[12] D[11] D[10] D[9] D[8] D[7] D[6] D[5]
+ D[4] D[3] D[2] D[1] D[0] load[15] load[14] load[13] load[12] load[11]
+ load[10] load[9] load[8] load[7] load[6] load[5] load[4] load[3] load[2]
+ load[1] load[0] en clk rst Q[15] Q[14] Q[13] Q[12] Q[11] Q[10] Q[9] Q[8] Q[7]
+ Q[6] Q[5] Q[4] Q[3] Q[2] Q[1] Q[0] Qbar[15] Qbar[14] Qbar[13] Qbar[12]
+ Qbar[11] Qbar[10] Qbar[9] Qbar[8] Qbar[7] Qbar[6] Qbar[5] Qbar[4] Qbar[3]
+ Qbar[2] Qbar[1] Qbar[0]
Xreg_Qbar_0 dffsr_ni $PINS Q=Qbar[0] QB=#dummy[0] D=nx696 CLK=clk S=nx4 R=nx0
Xix697 mux21_ni $PINS Y=nx696 A0=Qbar[0] A1=nx860 S0=nx1049
Xix861 inv01 $PINS Y=nx860 A=D[0]
Xix1 and02 $PINS Y=nx0 A0=nx1037 A1=load[0]
Xreg_Qbar_1 dffsr_ni $PINS Q=Qbar[1] QB=#dummy[1] D=nx706 CLK=clk S=nx12 R=nx8
Xix707 mux21_ni $PINS Y=nx706 A0=Qbar[1] A1=nx869 S0=nx1049
Xix870 inv01 $PINS Y=nx869 A=D[1]
Xix9 and02 $PINS Y=nx8 A0=nx1037 A1=load[1]
Xreg_Qbar_2 dffsr_ni $PINS Q=Qbar[2] QB=#dummy[2] D=nx716 CLK=clk S=nx20 R=nx16
Xix717 mux21_ni $PINS Y=nx716 A0=Qbar[2] A1=nx876 S0=nx1049
Xix877 inv01 $PINS Y=nx876 A=D[2]
Xix17 and02 $PINS Y=nx16 A0=nx1037 A1=load[2]
Xreg_Qbar_3 dffsr_ni $PINS Q=Qbar[3] QB=#dummy[3] D=nx726 CLK=clk S=nx28 R=nx24
Xix727 mux21_ni $PINS Y=nx726 A0=Qbar[3] A1=nx883 S0=nx1049
Xix884 inv01 $PINS Y=nx883 A=D[3]
Xix25 and02 $PINS Y=nx24 A0=nx1037 A1=load[3]
Xreg_Qbar_4 dffsr_ni $PINS Q=Qbar[4] QB=#dummy[4] D=nx736 CLK=clk S=nx36 R=nx32
Xix737 mux21_ni $PINS Y=nx736 A0=Qbar[4] A1=nx890 S0=nx1049
Xix891 inv01 $PINS Y=nx890 A=D[4]
Xix33 and02 $PINS Y=nx32 A0=nx1037 A1=load[4]
Xreg_Qbar_5 dffsr_ni $PINS Q=Qbar[5] QB=#dummy[5] D=nx746 CLK=clk S=nx44 R=nx40
Xix747 mux21_ni $PINS Y=nx746 A0=Qbar[5] A1=nx897 S0=nx1049
Xix898 inv01 $PINS Y=nx897 A=D[5]
Xix41 and02 $PINS Y=nx40 A0=nx1037 A1=load[5]
Xreg_Qbar_6 dffsr_ni $PINS Q=Qbar[6] QB=#dummy[6] D=nx756 CLK=clk S=nx52 R=nx48
Xix757 mux21_ni $PINS Y=nx756 A0=Qbar[6] A1=nx904 S0=nx1049
Xix905 inv01 $PINS Y=nx904 A=D[6]
Xix49 and02 $PINS Y=nx48 A0=nx1037 A1=load[6]
Xreg_Qbar_7 dffsr_ni $PINS Q=Qbar[7] QB=#dummy[7] D=nx766 CLK=clk S=nx60 R=nx56
Xix767 mux21_ni $PINS Y=nx766 A0=Qbar[7] A1=nx911 S0=nx1051
Xix912 inv01 $PINS Y=nx911 A=D[7]
Xix57 and02 $PINS Y=nx56 A0=nx1039 A1=load[7]
Xreg_Qbar_8 dffsr_ni $PINS Q=Qbar[8] QB=#dummy[8] D=nx776 CLK=clk S=nx68 R=nx64
Xix777 mux21_ni $PINS Y=nx776 A0=Qbar[8] A1=nx918 S0=nx1051
Xix919 inv01 $PINS Y=nx918 A=D[8]
Xix65 and02 $PINS Y=nx64 A0=nx1039 A1=load[8]
Xreg_Qbar_9 dffsr_ni $PINS Q=Qbar[9] QB=#dummy[9] D=nx786 CLK=clk S=nx76 R=nx72
Xix787 mux21_ni $PINS Y=nx786 A0=Qbar[9] A1=nx925 S0=nx1051
Xix926 inv01 $PINS Y=nx925 A=D[9]
Xix73 and02 $PINS Y=nx72 A0=nx1039 A1=load[9]
Xreg_Qbar_10 dffsr_ni $PINS Q=Qbar[10] QB=#dummy[10] D=nx796 CLK=clk S=nx84
+ R=nx80
Xix797 mux21_ni $PINS Y=nx796 A0=Qbar[10] A1=nx932 S0=nx1051
Xix933 inv01 $PINS Y=nx932 A=D[10]
Xix81 and02 $PINS Y=nx80 A0=nx1039 A1=load[10]
Xreg_Qbar_11 dffsr_ni $PINS Q=Qbar[11] QB=#dummy[11] D=nx806 CLK=clk S=nx92
+ R=nx88
Xix807 mux21_ni $PINS Y=nx806 A0=Qbar[11] A1=nx939 S0=nx1051
Xix940 inv01 $PINS Y=nx939 A=D[11]
Xix89 and02 $PINS Y=nx88 A0=nx1039 A1=load[11]
Xreg_Qbar_12 dffsr_ni $PINS Q=Qbar[12] QB=#dummy[12] D=nx816 CLK=clk S=nx100
+ R=nx96
Xix817 mux21_ni $PINS Y=nx816 A0=Qbar[12] A1=nx946 S0=nx1051
Xix947 inv01 $PINS Y=nx946 A=D[12]
Xix97 and02 $PINS Y=nx96 A0=nx1039 A1=load[12]
Xreg_Qbar_13 dffsr_ni $PINS Q=Qbar[13] QB=#dummy[13] D=nx826 CLK=clk S=nx108
+ R=nx104
Xix827 mux21_ni $PINS Y=nx826 A0=Qbar[13] A1=nx953 S0=nx1051
Xix954 inv01 $PINS Y=nx953 A=D[13]
Xix105 and02 $PINS Y=nx104 A0=nx1039 A1=load[13]
Xreg_Qbar_14 dffsr_ni $PINS Q=Qbar[14] QB=#dummy[14] D=nx836 CLK=clk S=nx116
+ R=nx112
Xix837 mux21_ni $PINS Y=nx836 A0=Qbar[14] A1=nx960 S0=nx1053
Xix961 inv01 $PINS Y=nx960 A=D[14]
Xix113 and02 $PINS Y=nx112 A0=nx1041 A1=load[14]
Xreg_Qbar_15 dffsr_ni $PINS Q=Qbar[15] QB=#dummy[15] D=nx846 CLK=clk S=nx124
+ R=nx120
Xix121 and02 $PINS Y=nx120 A0=nx1041 A1=load[15]
Xreg_Q_0 dffsr_ni $PINS Q=Q[0] QB=#dummy[16] D=nx536 CLK=clk S=nx0 R=nx4
Xix537 mux21_ni $PINS Y=nx536 A0=Q[0] A1=D[0] S0=nx1053
Xreg_Q_1 dffsr_ni $PINS Q=Q[1] QB=#dummy[17] D=nx546 CLK=clk S=nx8 R=nx12
Xix547 mux21_ni $PINS Y=nx546 A0=Q[1] A1=D[1] S0=nx1053
Xreg_Q_2 dffsr_ni $PINS Q=Q[2] QB=#dummy[18] D=nx556 CLK=clk S=nx16 R=nx20
Xix557 mux21_ni $PINS Y=nx556 A0=Q[2] A1=D[2] S0=nx1053
Xreg_Q_3 dffsr_ni $PINS Q=Q[3] QB=#dummy[19] D=nx566 CLK=clk S=nx24 R=nx28
Xix567 mux21_ni $PINS Y=nx566 A0=Q[3] A1=D[3] S0=nx1053
Xreg_Q_4 dffsr_ni $PINS Q=Q[4] QB=#dummy[20] D=nx576 CLK=clk S=nx32 R=nx36
Xix577 mux21_ni $PINS Y=nx576 A0=Q[4] A1=D[4] S0=nx1053
Xreg_Q_5 dffsr_ni $PINS Q=Q[5] QB=#dummy[21] D=nx586 CLK=clk S=nx40 R=nx44
Xix587 mux21_ni $PINS Y=nx586 A0=Q[5] A1=D[5] S0=nx1055
Xreg_Q_6 dffsr_ni $PINS Q=Q[6] QB=#dummy[22] D=nx596 CLK=clk S=nx48 R=nx52
Xix597 mux21_ni $PINS Y=nx596 A0=Q[6] A1=D[6] S0=nx1055
Xreg_Q_7 dffsr_ni $PINS Q=Q[7] QB=#dummy[23] D=nx606 CLK=clk S=nx56 R=nx60
Xix607 mux21_ni $PINS Y=nx606 A0=Q[7] A1=D[7] S0=nx1055
Xreg_Q_8 dffsr_ni $PINS Q=Q[8] QB=#dummy[24] D=nx616 CLK=clk S=nx64 R=nx68
Xix617 mux21_ni $PINS Y=nx616 A0=Q[8] A1=D[8] S0=nx1055
Xreg_Q_9 dffsr_ni $PINS Q=Q[9] QB=#dummy[25] D=nx626 CLK=clk S=nx72 R=nx76
Xix627 mux21_ni $PINS Y=nx626 A0=Q[9] A1=D[9] S0=nx1055
Xreg_Q_10 dffsr_ni $PINS Q=Q[10] QB=#dummy[26] D=nx636 CLK=clk S=nx80 R=nx84
Xix637 mux21_ni $PINS Y=nx636 A0=Q[10] A1=D[10] S0=nx1055
Xreg_Q_11 dffsr_ni $PINS Q=Q[11] QB=#dummy[27] D=nx646 CLK=clk S=nx88 R=nx92
Xix647 mux21_ni $PINS Y=nx646 A0=Q[11] A1=D[11] S0=nx1055
Xreg_Q_12 dffsr_ni $PINS Q=Q[12] QB=#dummy[28] D=nx656 CLK=clk S=nx96 R=nx100
Xix657 mux21_ni $PINS Y=nx656 A0=Q[12] A1=D[12] S0=nx1057
Xreg_Q_13 dffsr_ni $PINS Q=Q[13] QB=#dummy[29] D=nx666 CLK=clk S=nx104 R=nx108
Xix667 mux21_ni $PINS Y=nx666 A0=Q[13] A1=D[13] S0=nx1057
Xreg_Q_14 dffsr_ni $PINS Q=Q[14] QB=#dummy[30] D=nx676 CLK=clk S=nx112 R=nx116
Xix677 mux21_ni $PINS Y=nx676 A0=Q[14] A1=D[14] S0=nx1057
Xreg_Q_15 dffsr_ni $PINS Q=Q[15] QB=#dummy[31] D=nx686 CLK=clk S=nx120 R=nx124
Xix687 mux21_ni $PINS Y=nx686 A0=Q[15] A1=D[15] S0=nx1057
Xix5 nor02ii $PINS Y=nx4 A0=load[0] A1=nx1041
Xix13 nor02ii $PINS Y=nx12 A0=load[1] A1=nx1041
Xix21 nor02ii $PINS Y=nx20 A0=load[2] A1=nx1041
Xix29 nor02ii $PINS Y=nx28 A0=load[3] A1=nx1041
Xix37 nor02ii $PINS Y=nx36 A0=load[4] A1=nx1041
Xix45 nor02ii $PINS Y=nx44 A0=load[5] A1=nx1043
Xix53 nor02ii $PINS Y=nx52 A0=load[6] A1=nx1043
Xix61 nor02ii $PINS Y=nx60 A0=load[7] A1=nx1043
Xix69 nor02ii $PINS Y=nx68 A0=load[8] A1=nx1043
Xix77 nor02ii $PINS Y=nx76 A0=load[9] A1=nx1043
Xix85 nor02ii $PINS Y=nx84 A0=load[10] A1=nx1043
Xix93 nor02ii $PINS Y=nx92 A0=load[11] A1=nx1043
Xix101 nor02ii $PINS Y=nx100 A0=load[12] A1=nx1045
Xix109 nor02ii $PINS Y=nx108 A0=load[13] A1=nx1045
Xix117 nor02ii $PINS Y=nx116 A0=load[14] A1=nx1045
Xix125 nor02ii $PINS Y=nx124 A0=load[15] A1=nx1045
Xix1036 inv01 $PINS Y=nx1037 A=nx1035_XX0_XREP3
Xix1038 inv01 $PINS Y=nx1039 A=nx1035_XX0_XREP3
Xix1040 inv01 $PINS Y=nx1041 A=nx1035
Xix1042 inv01 $PINS Y=nx1043 A=nx1035
Xix1044 inv01 $PINS Y=nx1045 A=nx1035
Xix1048 inv02 $PINS Y=nx1049 A=nx1047_XX0_XREP1
Xix1050 inv02 $PINS Y=nx1051 A=nx1047_XX0_XREP1
Xix1054 inv02 $PINS Y=nx1055 A=nx1047
Xix1056 inv02 $PINS Y=nx1057 A=nx1047
Xix1046 inv01 $PINS Y=nx1047 A=en
Xix1046_0_XREP1 inv01 $PINS Y=nx1047_XX0_XREP1 A=en
Xix1034 inv01 $PINS Y=nx1035 A=rst
Xix1034_0_XREP3 inv01 $PINS Y=nx1035_XX0_XREP3 A=rst
Xix1095 inv02 $PINS Y=nx1094 A=D[15]
Xreg_nx1053 inv02 $PINS Y=nx1053 A=nx1047
Xreg_nx846 ao22 $PINS Y=nx846 A0=Qbar[15] A1=nx1047 B0=nx1094 B1=nx1053
.ENDS

.SUBCKT Mux2_16 A[15] A[14] A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5]
+ A[4] A[3] A[2] A[1] A[0] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7]
+ B[6] B[5] B[4] B[3] B[2] B[1] B[0] S C[15] C[14] C[13] C[12] C[11] C[10] C[9]
+ C[8] C[7] C[6] C[5] C[4] C[3] C[2] C[1] C[0]
Xix15 mux21_ni $PINS Y=C[1] A0=A[1] A1=B[1] S0=nx185
Xix23 mux21_ni $PINS Y=C[2] A0=A[2] A1=B[2] S0=nx185
Xix31 mux21_ni $PINS Y=C[3] A0=A[3] A1=B[3] S0=nx185
Xix39 mux21_ni $PINS Y=C[4] A0=A[4] A1=B[4] S0=nx185
Xix47 mux21_ni $PINS Y=C[5] A0=A[5] A1=B[5] S0=nx185
Xix55 mux21_ni $PINS Y=C[6] A0=A[6] A1=B[6] S0=nx185
Xix71 mux21_ni $PINS Y=C[8] A0=A[8] A1=B[8] S0=nx185
Xix79 mux21_ni $PINS Y=C[9] A0=A[9] A1=B[9] S0=nx187
Xix87 mux21_ni $PINS Y=C[10] A0=A[10] A1=B[10] S0=nx187
Xix95 mux21_ni $PINS Y=C[11] A0=A[11] A1=B[11] S0=nx187
Xix103 mux21_ni $PINS Y=C[12] A0=A[12] A1=B[12] S0=nx187
Xix111 mux21_ni $PINS Y=C[13] A0=A[13] A1=B[13] S0=nx187
Xix119 mux21_ni $PINS Y=C[14] A0=A[14] A1=B[14] S0=nx187
Xreg_C_7 ao22 $PINS Y=C[7] A0=A[7] A1=nx173 B0=B[7] B1=nx187
Xreg_C_0 ao22 $PINS Y=C[0] A0=A[0] A1=nx173 B0=B[0] B1=nx189
Xreg_nx173 inv02 $PINS Y=nx173 A=S
Xreg_C_15 ao22 $PINS Y=C[15] A0=A[15] A1=nx173 B0=B[15] B1=nx189
Xix184 inv02 $PINS Y=nx185 A=nx173
Xix186 inv02 $PINS Y=nx187 A=nx173
Xix188 inv02 $PINS Y=nx189 A=nx173
.ENDS

.SUBCKT CounterUpDown_16 load[15] load[14] load[13] load[12] load[11] load[10]
+ load[9] load[8] load[7] load[6] load[5] load[4] load[3] load[2] load[1]
+ load[0] resetValue[15] resetValue[14] resetValue[13] resetValue[12]
+ resetValue[11] resetValue[10] resetValue[9] resetValue[8] resetValue[7]
+ resetValue[6] resetValue[5] resetValue[4] resetValue[3] resetValue[2]
+ resetValue[1] resetValue[0] clk en rst isLoad upOrDown count[15] count[14]
+ count[13] count[12] count[11] count[10] count[9] count[8] count[7] count[6]
+ count[5] count[4] count[3] count[2] count[1] count[0]
XnextCount NBitAdder_16 $PINS a[15]=count[15] a[14]=count[14] a[13]=count[13]
+ a[12]=count[12] a[11]=count[11] a[10]=count[10] a[9]=count[9] a[8]=count[8]
+ a[7]=count[7] a[6]=count[6] a[5]=count[5] a[4]=count[4] a[3]=count[3]
+ a[2]=count[2] a[1]=count[1] a[0]=count[0] b[15]=upOrDown b[14]=upOrDown
+ b[13]=upOrDown b[12]=upOrDown b[11]=upOrDown b[10]=upOrDown b[9]=upOrDown
+ b[8]=upOrDown b[7]=upOrDown b[6]=upOrDown b[5]=upOrDown b[4]=upOrDown
+ b[3]=upOrDown b[2]=upOrDown b[1]=upOrDown b[0]=upOrDown carryIn=NOT_upOrDown
+ sum[15]=countAdded_15 sum[14]=countAdded_14 sum[13]=countAdded_13
+ sum[12]=countAdded_12 sum[11]=countAdded_11 sum[10]=countAdded_10
+ sum[9]=countAdded_9 sum[8]=countAdded_8 sum[7]=countAdded_7 sum[6]=countAdded_6
+ sum[5]=countAdded_5 sum[4]=countAdded_4 sum[3]=countAdded_3 sum[2]=countAdded_2
+ sum[1]=countAdded_1 sum[0]=countAdded_0 carryOut=#dummy[0]
Xix761 inv01 $PINS Y=NOT_upOrDown A=upOrDown
Xreg_currentCount_0 dffsr_ni $PINS Q=count[0] QB=#dummy[1] D=nx598 CLK=clk
+ S=nx10 R=nx14
Xix599 mux21_ni $PINS Y=nx598 A0=nx8 A1=count[0] S0=nx867
Xix9 mux21_ni $PINS Y=nx8 A0=load[0] A1=countAdded_0 S0=nx883
Xix766 nor02_2x $PINS Y=nx765 A0=nx883 A1=isLoad
Xix11 and02 $PINS Y=nx10 A0=resetValue[0] A1=rst
Xreg_currentCount_1 dffsr_ni $PINS Q=count[1] QB=#dummy[2] D=nx608 CLK=clk
+ S=nx26 R=nx30
Xix609 mux21_ni $PINS Y=nx608 A0=nx24 A1=count[1] S0=nx867
Xix25 mux21_ni $PINS Y=nx24 A0=load[1] A1=countAdded_1 S0=nx883
Xix27 and02 $PINS Y=nx26 A0=resetValue[1] A1=rst
Xreg_currentCount_2 dffsr_ni $PINS Q=count[2] QB=#dummy[3] D=nx618 CLK=clk
+ S=nx42 R=nx46
Xix619 mux21_ni $PINS Y=nx618 A0=nx40 A1=count[2] S0=nx867
Xix41 mux21_ni $PINS Y=nx40 A0=load[2] A1=countAdded_2 S0=nx883
Xix43 and02 $PINS Y=nx42 A0=resetValue[2] A1=rst
Xreg_currentCount_3 dffsr_ni $PINS Q=count[3] QB=#dummy[4] D=nx628 CLK=clk
+ S=nx58 R=nx62
Xix629 mux21_ni $PINS Y=nx628 A0=nx56 A1=count[3] S0=nx867
Xix57 mux21_ni $PINS Y=nx56 A0=load[3] A1=countAdded_3 S0=nx883
Xix59 and02 $PINS Y=nx58 A0=resetValue[3] A1=rst
Xreg_currentCount_4 dffsr_ni $PINS Q=count[4] QB=#dummy[5] D=nx638 CLK=clk
+ S=nx74 R=nx78
Xix639 mux21_ni $PINS Y=nx638 A0=nx72 A1=count[4] S0=nx867
Xix73 mux21_ni $PINS Y=nx72 A0=load[4] A1=countAdded_4 S0=nx883
Xix75 and02 $PINS Y=nx74 A0=resetValue[4] A1=rst
Xreg_currentCount_5 dffsr_ni $PINS Q=count[5] QB=#dummy[6] D=nx648 CLK=clk
+ S=nx90 R=nx94
Xix649 mux21_ni $PINS Y=nx648 A0=nx88 A1=count[5] S0=nx867
Xix89 mux21_ni $PINS Y=nx88 A0=load[5] A1=countAdded_5 S0=nx883
Xix91 and02 $PINS Y=nx90 A0=resetValue[5] A1=rst
Xreg_currentCount_6 dffsr_ni $PINS Q=count[6] QB=#dummy[7] D=nx658 CLK=clk
+ S=nx106 R=nx110
Xix659 mux21_ni $PINS Y=nx658 A0=nx104 A1=count[6] S0=nx869
Xix105 mux21_ni $PINS Y=nx104 A0=load[6] A1=countAdded_6 S0=nx885
Xix107 and02 $PINS Y=nx106 A0=resetValue[6] A1=rst
Xreg_currentCount_7 dffsr_ni $PINS Q=count[7] QB=#dummy[8] D=nx668 CLK=clk
+ S=nx122 R=nx126
Xix669 mux21_ni $PINS Y=nx668 A0=nx120 A1=count[7] S0=nx869
Xix121 mux21_ni $PINS Y=nx120 A0=load[7] A1=countAdded_7 S0=nx885
Xix123 and02 $PINS Y=nx122 A0=resetValue[7] A1=rst
Xreg_currentCount_8 dffsr_ni $PINS Q=count[8] QB=#dummy[9] D=nx678 CLK=clk
+ S=nx138 R=nx142
Xix679 mux21_ni $PINS Y=nx678 A0=nx136 A1=count[8] S0=nx869
Xix137 mux21_ni $PINS Y=nx136 A0=load[8] A1=countAdded_8 S0=nx885
Xix139 and02 $PINS Y=nx138 A0=resetValue[8] A1=rst
Xreg_currentCount_9 dffsr_ni $PINS Q=count[9] QB=#dummy[10] D=nx688 CLK=clk
+ S=nx154 R=nx158
Xix689 mux21_ni $PINS Y=nx688 A0=nx152 A1=count[9] S0=nx869
Xix153 mux21_ni $PINS Y=nx152 A0=load[9] A1=countAdded_9 S0=nx885
Xix155 and02 $PINS Y=nx154 A0=resetValue[9] A1=rst
Xreg_currentCount_10 dffsr_ni $PINS Q=count[10] QB=#dummy[11] D=nx698 CLK=clk
+ S=nx170 R=nx174
Xix699 mux21_ni $PINS Y=nx698 A0=nx168 A1=count[10] S0=nx869
Xix169 mux21_ni $PINS Y=nx168 A0=load[10] A1=countAdded_10 S0=nx885
Xix171 and02 $PINS Y=nx170 A0=resetValue[10] A1=rst
Xreg_currentCount_11 dffsr_ni $PINS Q=count[11] QB=#dummy[12] D=nx708 CLK=clk
+ S=nx186 R=nx190
Xix709 mux21_ni $PINS Y=nx708 A0=nx184 A1=count[11] S0=nx869
Xix185 mux21_ni $PINS Y=nx184 A0=load[11] A1=countAdded_11 S0=nx885
Xix187 and02 $PINS Y=nx186 A0=resetValue[11] A1=rst
Xreg_currentCount_12 dffsr_ni $PINS Q=count[12] QB=#dummy[13] D=nx718 CLK=clk
+ S=nx202 R=nx206
Xix719 mux21_ni $PINS Y=nx718 A0=nx200 A1=count[12] S0=nx765
Xix201 mux21_ni $PINS Y=nx200 A0=load[12] A1=countAdded_12 S0=nx885
Xix203 and02 $PINS Y=nx202 A0=resetValue[12] A1=rst
Xreg_currentCount_13 dffsr_ni $PINS Q=count[13] QB=#dummy[14] D=nx728 CLK=clk
+ S=nx218 R=nx222
Xix729 mux21_ni $PINS Y=nx728 A0=nx216 A1=count[13] S0=nx765
Xix217 mux21_ni $PINS Y=nx216 A0=load[13] A1=countAdded_13 S0=nx887
Xix219 and02 $PINS Y=nx218 A0=resetValue[13] A1=rst
Xreg_currentCount_14 dffsr_ni $PINS Q=count[14] QB=#dummy[15] D=nx738 CLK=clk
+ S=nx234 R=nx238
Xix739 mux21_ni $PINS Y=nx738 A0=nx232 A1=count[14] S0=nx765
Xix233 mux21_ni $PINS Y=nx232 A0=load[14] A1=countAdded_14 S0=nx887
Xix235 and02 $PINS Y=nx234 A0=resetValue[14] A1=rst
Xreg_currentCount_15 dffsr_ni $PINS Q=count[15] QB=#dummy[16] D=nx748 CLK=clk
+ S=nx250 R=nx254
Xix749 mux21_ni $PINS Y=nx748 A0=nx248 A1=count[15] S0=nx765
Xix249 mux21_ni $PINS Y=nx248 A0=load[15] A1=countAdded_15 S0=nx887
Xix251 and02 $PINS Y=nx250 A0=resetValue[15] A1=rst
Xix866 nor02_2x $PINS Y=nx867 A0=nx887 A1=isLoad
Xix868 nor02_2x $PINS Y=nx869 A0=nx887 A1=isLoad
Xix15 nor02ii $PINS Y=nx14 A0=resetValue[0] A1=rst
Xix31 nor02ii $PINS Y=nx30 A0=resetValue[1] A1=rst
Xix47 nor02ii $PINS Y=nx46 A0=resetValue[2] A1=rst
Xix63 nor02ii $PINS Y=nx62 A0=resetValue[3] A1=rst
Xix79 nor02ii $PINS Y=nx78 A0=resetValue[4] A1=rst
Xix95 nor02ii $PINS Y=nx94 A0=resetValue[5] A1=rst
Xix111 nor02ii $PINS Y=nx110 A0=resetValue[6] A1=rst
Xix127 nor02ii $PINS Y=nx126 A0=resetValue[7] A1=rst
Xix143 nor02ii $PINS Y=nx142 A0=resetValue[8] A1=rst
Xix159 nor02ii $PINS Y=nx158 A0=resetValue[9] A1=rst
Xix175 nor02ii $PINS Y=nx174 A0=resetValue[10] A1=rst
Xix191 nor02ii $PINS Y=nx190 A0=resetValue[11] A1=rst
Xix207 nor02ii $PINS Y=nx206 A0=resetValue[12] A1=rst
Xix223 nor02ii $PINS Y=nx222 A0=resetValue[13] A1=rst
Xix239 nor02ii $PINS Y=nx238 A0=resetValue[14] A1=rst
Xix255 nor02ii $PINS Y=nx254 A0=resetValue[15] A1=rst
Xix880 inv01 $PINS Y=nx881 A=en
Xix882 inv02 $PINS Y=nx883 A=nx881
Xix884 inv02 $PINS Y=nx885 A=nx881
Xix886 inv02 $PINS Y=nx887 A=nx881
.ENDS

.SUBCKT NBitAdder_16 a[15] a[14] a[13] a[12] a[11] a[10] a[9] a[8] a[7] a[6]
+ a[5] a[4] a[3] a[2] a[1] a[0] b[15] b[14] b[13] b[12] b[11] b[10] b[9] b[8]
+ b[7] b[6] b[5] b[4] b[3] b[2] b[1] b[0] carryIn sum[15] sum[14] sum[13]
+ sum[12] sum[11] sum[10] sum[9] sum[8] sum[7] sum[6] sum[5] sum[4] sum[3]
+ sum[2] sum[1] sum[0] carryOut
Xf0 FullAdder $PINS a=a[0] b=b[0] cin=carryIn s=sum[0] cout=temp_0
Xloop1_1_fx FullAdder $PINS a=a[1] b=b[1] cin=temp_0 s=sum[1] cout=temp_1
Xloop1_2_fx FullAdder $PINS a=a[2] b=b[2] cin=temp_1 s=sum[2] cout=temp_2
Xloop1_3_fx FullAdder $PINS a=a[3] b=b[3] cin=temp_2 s=sum[3] cout=temp_3
Xloop1_4_fx FullAdder $PINS a=a[4] b=b[4] cin=temp_3 s=sum[4] cout=temp_4
Xloop1_5_fx FullAdder $PINS a=a[5] b=b[5] cin=temp_4 s=sum[5] cout=temp_5
Xloop1_6_fx FullAdder $PINS a=a[6] b=b[6] cin=temp_5 s=sum[6] cout=temp_6
Xloop1_7_fx FullAdder $PINS a=a[7] b=b[7] cin=temp_6 s=sum[7] cout=temp_7
Xloop1_8_fx FullAdder $PINS a=a[8] b=b[8] cin=temp_7 s=sum[8] cout=temp_8
Xloop1_9_fx FullAdder $PINS a=a[9] b=b[9] cin=temp_8 s=sum[9] cout=temp_9
Xloop1_10_fx FullAdder $PINS a=a[10] b=b[10] cin=temp_9 s=sum[10] cout=temp_10
Xloop1_11_fx FullAdder $PINS a=a[11] b=b[11] cin=temp_10 s=sum[11] cout=temp_11
Xloop1_12_fx FullAdder $PINS a=a[12] b=b[12] cin=temp_11 s=sum[12] cout=temp_12
Xloop1_13_fx FullAdder $PINS a=a[13] b=b[13] cin=temp_12 s=sum[13] cout=temp_13
Xloop1_14_fx FullAdder $PINS a=a[14] b=b[14] cin=temp_13 s=sum[14] cout=temp_14
Xloop1_15_fx FullAdder $PINS a=a[15] b=b[15] cin=temp_14 s=sum[15]
+ cout=carryOut
.ENDS

.SUBCKT FullAdder a b cin s cout
Xix7 ao22 $PINS Y=cout A0=b A1=a B0=cin B1=nx0
Xix9 xnor2 $PINS Y=s A0=nx69 A1=cin
Xix70 xnor2 $PINS Y=nx69 A0=a A1=b
Xix1 inv01 $PINS Y=nx0 A=nx69
.ENDS

.SUBCKT RisingHolderFullCycle transition clk rst f
Xreg_f dffr $PINS Q=f QB=#dummy[0] D=nx0 CLK=transition R=nx8
Xix9 or02 $PINS Y=nx8 A0=d A1=rst
Xreg_d dff $PINS Q=d QB=#dummy[1] D=f CLK=clk
.ENDS
